<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mcp980x_twi_temp_sensor_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mcp980x_twi_temp_sensor_example_sram.ewp</path>
	</project>
</workspace>
