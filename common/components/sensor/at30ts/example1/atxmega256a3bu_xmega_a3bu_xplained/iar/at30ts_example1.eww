<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at30ts_example1.ewp</path>
	</project>
</workspace>
