# IAR project at30ts_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: _AT30TSE758_; _ATAVRTEMPSENSORX_; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../../xmega/drivers/pmic; ../..; ../../../../../../../xmega/utils; ../../../../../../services/gfx_mono; ../../../../../../services/twi; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/drivers/nvm; ../../../../../../utils; ../../../../../display/st7565r; ../../../../../../services/clock; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../xmega/boards; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../xmega/drivers/twi; ../../..; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _AT30TSE758_; _ATAVRTEMPSENSORX_; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/twi
    ../../../../../../../xmega/drivers/twi/: twis.c twim.c twis.h twi_common.h twim.h
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../../../xmega/utils/: status_codes.h compiler.h progmem.h assembler.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group common/services/gfx_mono
    ../../../../../../services/gfx_mono/: gfx_mono_framebuffer.c gfx_mono_generic.c gfx_mono_text.c gfx_mono_c12832_a1z.c sysfont.c gfx_mono.h gfx_mono_text.h gfx_mono_generic.h sysfont.h gfx_mono_framebuffer.h gfx_mono_c12832_a1z.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/twi
    ../../../../../../services/twi/: twi_slave.h twi_master.h
  group common/services/twi/xmega_twi
    ../../../../../../services/twi/xmega_twi/: twi_master.h twi_slave.h
  group common/components/sensor/at30ts
    ../../../: at30ts.c at30ts.h
  group common/components/sensor/at30ts/example1
    ../../: at30ts_example1.c
  group common/components/sensor/at30ts/example1/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_usart_spi.h conf_at30ts.h conf_clock.h conf_twim.h conf_board.h conf_example.h conf_sysfont.h conf_st7565r.h
  group common/components/sensor/at30ts/example1/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/components/display/st7565r
    ../../../../../display/st7565r/: st7565r.c st7565r.h
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../boards/: board.h
