<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at25dfx_at25dfx_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\at25dfx_at25dfx_example_sram.ewp</path>
	</project>
</workspace>
