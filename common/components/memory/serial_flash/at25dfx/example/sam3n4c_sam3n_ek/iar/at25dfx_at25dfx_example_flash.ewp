# IAR project at25dfx_at25dfx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../../../sam/boards; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../services/clock; ../../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/boards/sam3n_ek; ../../../../../../../utils; ../../..; ../../../../../../../services/gpio; ../../../../../../../services/ioport; ../../../../../../../services/spi/sam_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_at25dfx_example_flash.bin
  ILINK.IlinkOutputFile: at25dfx_at25dfx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam3n_ek
    ../../../../../../../../sam/boards/sam3n_ek/: init.c led.c sam3n_ek.h led.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c system_sam3n.h exceptions.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../../../sam/utils/cmsis/sam3n/include/: sam3n2a.h sam3n1a.h sam3n2c.h sam3n4b.h sam3n.h sam3n4a.h sam3n4c.h sam3n1b.h sam3n2b.h sam3n1c.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_pmc.h instance_rtt.h instance_adc.h instance_pwm.h instance_uart0.h instance_matrix.h instance_usart1.h instance_gpbr.h instance_piob.h instance_tc1.h instance_chipid.h instance_uart1.h instance_wdt.h instance_tc0.h instance_usart0.h instance_rstc.h instance_spi.h instance_pioa.h instance_efc.h instance_pioc.h instance_twi0.h instance_dacc.h instance_supc.h instance_rtc.h instance_twi1.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../../../sam/utils/cmsis/sam3n/include/component/: component_chipid.h component_gpbr.h component_twi.h component_adc.h component_matrix.h component_rtc.h component_dacc.h component_usart.h component_pwm.h component_rstc.h component_pio.h component_supc.h component_pmc.h component_pdc.h component_wdt.h component_uart.h component_rtt.h component_tc.h component_efc.h component_spi.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n1c.h pio_sam3n4b.h pio_sam3n2b.h pio_sam3n1b.h pio_sam3n1a.h pio_sam3n4c.h pio_sam3n4a.h pio_sam3n2a.h pio_sam3n2c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx_hal_spi.c at25dfx.c at25dfx_hal_spi.h at25dfx.h
  group common/components/memory/serial_flash/at25dfx/example
    ../../: at25dfx_example.c
  group common/components/memory/serial_flash/at25dfx/example/sam3n4c_sam3n_ek
    ../: conf_at25dfx.h conf_clock.h conf_board.h conf_spi_master.h
  group common/components/memory/serial_flash/at25dfx/example/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam3n
    ../../../../../../../services/clock/sam3n/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../boards/: board.h
