# IAR project at25dfx_at25dfx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMP16C_0 Atmel ATSAM4CMP16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../sam/utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ..; ../../../../../../../../sam/boards/sam4cmp_db; ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/drivers/spi; ../../../../../../../utils; ../../..; ../../../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../../services/ioport; ../../../../../../../services/spi/sam_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_at25dfx_example_flash.bin
  ILINK.IlinkOutputFile: at25dfx_at25dfx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cmp16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../../services/clock/sam4cm/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx.c at25dfx_hal_spi.c at25dfx.h at25dfx_hal_spi.h
  group common/components/memory/serial_flash/at25dfx/example
    ../../: at25dfx_example.c
  group common/components/memory/serial_flash/at25dfx/example/sam4cmp16c_sam4cmp_db
    ../: conf_at25dfx.h conf_clock.h conf_board.h conf_spi_master.h
  group common/components/memory/serial_flash/at25dfx/example/sam4cmp16c_sam4cmp_db/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_0.h sam4cmp8c_0.h sam4cms16c_1.h sam4cmp16c_0.h sam4cmp8c_1.h sam4cm.h system_sam4cm.h sam4cms8c_1.h sam4cms16c_0.h sam4cmp16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: cmcc0.h efc.h smc1.h ipc1.h uart1.h spi0.h rtc.h matrix0.h wdt.h chipid.h usart0.h usart2.h rtt.h tc0.h tc1.h usart3.h rswdt.h adc.h gpbr.h twi1.h ipc0.h pioa.h pmc.h pioc.h uart0.h usart1.h matrix1.h rstc.h twi0.h supc.h smc0.h trng.h slcdc.h cmcc1.h piob.h pwm.h icm.h spi1.h aes.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: pwm.h gpbr.h tc.h rtc.h adc.h chipid.h matrix.h rswdt.h twi.h rstc.h efc.h slcdc.h trng.h rtt.h supc.h pdc.h spi.h pio.h smc.h pmc.h uart.h aes.h icm.h usart.h wdt.h ipc.h cmcc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cmp8c.h sam4cms16c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/boards/sam4cmp_db
    ../../../../../../../../sam/boards/sam4cmp_db/: init.c sam4cmp_db.h led.h
