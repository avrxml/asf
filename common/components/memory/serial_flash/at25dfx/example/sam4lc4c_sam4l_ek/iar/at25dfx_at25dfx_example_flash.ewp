# IAR project at25dfx_at25dfx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/usart; ../..; ../../../../../../../../sam/utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../boards; ../../../../../../../../sam/boards/sam4l_ek; ..; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/bpm; ../../../../../../../utils; ../../..; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../services/spi/sam_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_at25dfx_example_flash.bin
  ILINK.IlinkOutputFile: at25dfx_at25dfx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../services/clock/: osc.h pll.h genclk.h dfll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../services/clock/sam4l/: osc.c pll.c dfll.c sysclk.c osc.h sysclk.h genclk.h dfll.h pll.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_gpio.h
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx.c at25dfx_hal_spi.c at25dfx.h at25dfx_hal_spi.h
  group common/components/memory/serial_flash/at25dfx/example
    ../../: at25dfx_example.c
  group common/components/memory/serial_flash/at25dfx/example/sam4lc4c_sam4l_ek
    ../: conf_clock.h conf_at25dfx.h conf_board.h conf_spi_master.h
  group common/components/memory/serial_flash/at25dfx/example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_ek
    ../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c board_monitor.h sam4l_ek.h led.h
