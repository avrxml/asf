<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at25dfx_unit_tests_flash.ewp</path>
	</project>
</workspace>
