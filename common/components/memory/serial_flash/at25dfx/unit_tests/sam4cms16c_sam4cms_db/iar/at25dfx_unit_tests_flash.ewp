# IAR project at25dfx_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  ICCARM.CCIncludePath2: ..; ../../../../../../../services/spi/sam_spi; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../services/serial; ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../../../../sam/drivers/spi; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam4cms_db; ../../../../../../../services/serial/sam_uart; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_unit_tests_flash.bin
  ILINK.IlinkOutputFile: at25dfx_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../../services/clock/sam4cm/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx_hal_spi.c at25dfx.c at25dfx.h at25dfx_hal_spi.h
  group common/components/memory/serial_flash/at25dfx/unit_tests
    ../../: unit_tests.c
  group common/components/memory/serial_flash/at25dfx/unit_tests/sam4cms16c_sam4cms_db
    ../: conf_at25dfx.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_test.h
  group common/components/memory/serial_flash/at25dfx/unit_tests/sam4cms16c_sam4cms_db/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_0.h sam4cmp8c_0.h sam4cms16c_1.h sam4cmp16c_0.h sam4cmp8c_1.h sam4cm.h system_sam4cm.h sam4cms8c_1.h sam4cms16c_0.h sam4cmp16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: cmcc0.h efc.h smc1.h pwm.h ipc1.h uart1.h spi0.h rtc.h rstc.h matrix0.h wdt.h chipid.h usart3.h usart0.h pioa.h rtt.h tc0.h tc1.h rswdt.h adc.h gpbr.h twi1.h ipc0.h pmc.h pioc.h uart0.h usart2.h usart1.h matrix1.h twi0.h supc.h smc0.h trng.h slcdc.h cmcc1.h piob.h icm.h spi1.h aes.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: pwm.h gpbr.h tc.h rtc.h adc.h chipid.h matrix.h rswdt.h rstc.h efc.h slcdc.h trng.h rtt.h supc.h pdc.h spi.h twi.h pio.h smc.h pmc.h uart.h aes.h icm.h usart.h wdt.h ipc.h cmcc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cmp8c.h sam4cms16c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4cms_db
    ../../../../../../../../sam/boards/sam4cms_db/: init.c led.h sam4cms_db.h
