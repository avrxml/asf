# IAR project sd_mmc_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ..; ../..; ../../../../../../../sam/drivers/efc; ../../../../../../../sam/utils/fpu; ../../../../../../services/serial; ../../../../../../../sam/boards/samg53_xplained_pro; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/drivers/supc; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/utils/cmsis/samg/samg53/source/templates; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils/cmsis/samg/samg53/include; ../../../../../../../sam/utils; ../../../../../../services/spi; ../../../../../../services/serial/sam_uart; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example1_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h
  group common/components/memory/sd_mmc/example1
    ../../: example.c time_tick_sam.c time_tick.h
  group common/components/memory/sd_mmc/example1/samg53n19_samg_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_spi_master.h conf_sd_mmc.h conf_example.h conf_clock.h
  group common/components/memory/sd_mmc/example1/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/samg
    ../../../../../../services/clock/samg/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../../../sam/utils/cmsis/samg/samg53/source/templates/: exceptions.c system_samg53.c exceptions.h system_samg53.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/: samg53.h samg53n19.h samg53g19.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/instance/: instance_tc1.h instance_twi1.h instance_gpbr.h instance_pdmic0.h instance_spi.h instance_rtc.h instance_i2sc0.h instance_efc.h instance_matrix.h instance_mem2mem.h instance_i2sc1.h instance_chipid.h instance_tc0.h instance_rtt.h instance_twi2.h instance_adc.h instance_twi0.h instance_rstc.h instance_pdmic1.h instance_usart.h instance_supc.h instance_piob.h instance_uart1.h instance_wdt.h instance_uart0.h instance_pmc.h instance_pioa.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/component/: component_adc.h component_spi.h component_pdc.h component_pmc.h component_gpbr.h component_wdt.h component_matrix.h component_tc.h component_rstc.h component_efc.h component_uart.h component_usart.h component_chipid.h component_pdmic.h component_supc.h component_twihs.h component_twi.h component_pio.h component_rtt.h component_mem2mem.h component_rtc.h component_i2sc.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/boards/samg53_xplained_pro
    ../../../../../../../sam/boards/samg53_xplained_pro/: board_init.c samg53_xplained_pro.h led.h
