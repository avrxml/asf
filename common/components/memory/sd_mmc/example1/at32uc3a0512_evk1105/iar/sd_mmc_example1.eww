<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sd_mmc_example1.ewp</path>
	</project>
</workspace>
