# IAR project sd_mmc_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../services/gpio; ..; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../services/serial/xmega_usart; ../../../../../../../xmega/utils; ../../../../../../services/ioport; ../../../../../../../xmega/boards/xmega_c3_xplained; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../../../../xmega/drivers/nvm; ../../../../../../utils; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/spi; ../..; ../../../../../../services/delay; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc.c sd_mmc_spi.h sd_mmc_protocol.h sd_mmc.h
  group common/components/memory/sd_mmc/example1
    ../../: example.c time_tick_xmega.c time_tick.h
  group common/components/memory/sd_mmc/example1/atxmega384c3_xmega_c3_xplained
    ../: conf_usart_spi.h conf_clock.h conf_board.h conf_example.h conf_sd_mmc.h conf_usart_serial.h
  group common/components/memory/sd_mmc/example1/atxmega384c3_xmega_c3_xplained/iar
    ./: asf.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../services/serial/xmega_usart/: usart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_c3_xplained
    ../../../../../../../xmega/boards/xmega_c3_xplained/: init.c led.h xmega_c3_xplained.h
  group xmega/utils
    ../../../../../../../xmega/utils/: status_codes.h compiler.h assembler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
