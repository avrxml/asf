<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sd_mmc_example2.ewp</path>
	</project>
</workspace>
