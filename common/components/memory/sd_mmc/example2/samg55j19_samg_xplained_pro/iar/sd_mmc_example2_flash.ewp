# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; SD_MMC_ENABLE; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../sam/drivers/flexcom; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../../sam/drivers/efc; ../../../../../../../sam/utils/fpu; ../../../../../../services/serial; ../../../../../../services/ioport; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/drivers/supc; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../../../../../../sam/utils/cmsis/samg/samg55/include; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../services/delay; ../../../../../../../sam/utils; ../../../../../../services/spi; ../../../../../../services/serial/sam_uart; ../../../../../../boards; ../../../../../../../sam/drivers/rtc; ..; ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates; ../../../../../../../sam/drivers/usart; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/samg
    ../../../../../../services/clock/samg/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h sd_mmc_mem.h
  group common/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common/components/memory/sd_mmc/example2/samg55j19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_sleepmgr.h conf_example.h conf_spi_master.h
  group common/components/memory/sd_mmc/example2/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/drivers/flexcom
    ../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/efc
    ../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../../sam/boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h system_samg55.h samg55n19.h samg55g19.h samg55j18.h samg55j19.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: usart5.h twi0.h usart7.h matrix.h twi2.h i2sc1.h supc.h rtc.h mem2mem.h flexcom4.h flexcom6.h twi6.h udp.h pioa.h gpbr.h flexcom0.h spi1.h usart4.h spi2.h pmc.h flexcom2.h rtt.h twi3.h twi5.h tc1.h flexcom5.h spi6.h twi7.h i2sc0.h flexcom7.h usart2.h spi4.h flexcom1.h spi3.h usart3.h efc.h flexcom3.h pdmic1.h adc.h tc0.h cmcc.h spi7.h twi1.h crccu.h spi5.h usart1.h usart0.h rstc.h piob.h wdt.h pdmic0.h usart6.h chipid.h uhp.h spi0.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: matrix.h efc.h wdt.h flexcom.h crccu.h adc.h i2sc.h pio.h supc.h chipid.h twi.h mem2mem.h uhp.h gpbr.h cmcc.h rtt.h tc.h pmc.h spi.h usart.h pdc.h udp.h pdmic.h rtc.h rstc.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55j18.h samg55n19.h samg55g19.h samg55j19.h samg55g18.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
