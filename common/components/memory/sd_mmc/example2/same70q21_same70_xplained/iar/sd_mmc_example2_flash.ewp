# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; SD_MMC_ENABLE; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ..; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../../../sam/utils/cmsis/same70/include; ../..; ../../../../../../../sam/utils/fpu; ../../../../../../services/serial; ../../../../../../services/ioport; ../../../../../../../sam/drivers/mpu; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/same70_xplained; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../services/serial/sam_uart; ../../../../../../boards; ../../../../../../../sam/drivers/rtc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/xdmac; ../../../../../../../sam/drivers/hsmci; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/same70
    ../../../../../../services/clock/same70/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_protocol.h sd_mmc_mem.h
  group common/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common/components/memory/sd_mmc/example2/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_board.h conf_clock.h conf_sd_mmc.h conf_example.h
  group common/components/memory/sd_mmc/example2/same70q21_same70_xplained/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/boards/same70_xplained
    ../../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../sam/utils/cmsis/same70/include/: same70q20b.h same70n21b.h same70j19.h same70q20.h same70n20.h same70j21b.h same70j21.h same70q21.h same70q21b.h same70n19.h same70q19b.h same70j19b.h same70j20.h same70n20b.h same70n19b.h same70q19.h same70n21.h same70.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../sam/utils/cmsis/same70/include/instance/: rstc.h rswdt.h smc.h spi1.h isi.h afec0.h twihs0.h icm.h gpbr.h qspi.h uart4.h mcan0.h tc3.h piod.h rtt.h tc1.h aes.h dacc.h chipid.h hsmci.h efc.h sdramc.h uart1.h usbhs.h i2sc1.h pioc.h matrix.h tc2.h uart3.h usart1.h uart2.h pioe.h usart2.h xdmac.h supc.h spi0.h acc.h pwm0.h i2sc0.h trng.h usart0.h pioa.h wdt.h pmc.h utmi.h tc0.h twihs1.h gmac.h afec1.h twihs2.h rtc.h piob.h pwm1.h uart0.h mcan1.h ssc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../sam/utils/cmsis/same70/include/component/: matrix.h rswdt.h qspi.h twihs.h pmc.h tc.h dacc.h usbhs.h pwm.h rtt.h mcan.h ssc.h uart.h i2sc.h smc.h chipid.h acc.h efc.h sdramc.h wdt.h afec.h isi.h gmac.h xdmac.h utmi.h icm.h hsmci.h usart.h spi.h aes.h gpbr.h pio.h rtc.h rstc.h trng.h supc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../sam/utils/cmsis/same70/include/pio/: same70n19b.h same70q21b.h same70q19.h same70j20b.h same70q20.h same70n21b.h same70n20.h same70j19b.h same70j20.h same70n21.h same70j21.h same70j21b.h same70n20b.h same70q19b.h same70n19.h same70j19.h same70q21.h same70q20b.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/xdmac
    ../../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
