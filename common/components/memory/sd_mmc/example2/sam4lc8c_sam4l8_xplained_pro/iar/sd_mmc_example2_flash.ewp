# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC8C__; SD_MMC_ENABLE; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../services/spi/sam_spi; ../../../../../../boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../services/serial; ../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../sam/drivers/ast; ../../../../../../../sam/drivers/spi; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../../../../../../sam/drivers/wdt; ../../../../../../services/clock; ../../../../../../../sam/boards; ..; ../../../../../../utils/stdio/stdio_serial; ../../../../../../services/delay; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../services/serial/sam_uart; ../../../../../../../sam/drivers/flashcalw; ../../../../../../services/ioport; ../../../../../../../sam/boards/sam4l8_xplained_pro; ../../../../../../../sam/drivers/bpm; ../../../../../../services/spi; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h osc.h dfll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../services/clock/sam4l/: dfll.c pll.c osc.c sysclk.c dfll.h pll.h sysclk.h genclk.h osc.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_gpio.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h sd_mmc_mem.h
  group common/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common/components/memory/sd_mmc/example2/sam4lc8c_sam4l8_xplained_pro
    ../: conf_sleepmgr.h conf_example.h conf_ast.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_sd_mmc.h
  group common/components/memory/sd_mmc/example2/sam4lc8c_sam4l8_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_ast.c
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls8a.h sam4ls4a.h sam4ls8c.h sam4lc8a.h sam4lc4c.h sam4l.h sam4lc4a.h sam4lc2b.h sam4lc8b.h sam4ls4b.h sam4ls2a.h sam4ls2c.h sam4lc2c.h sam4lc2a.h sam4lc8c.h sam4ls4c.h sam4lc4b.h sam4ls2b.h sam4ls8b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_pm.h instance_iisc.h instance_chipid.h instance_crccu.h instance_gpio.h instance_freqm.h instance_dacc.h instance_pdca.h instance_aesa.h instance_twis0.h instance_picouart.h instance_parc.h instance_abdacb.h instance_trng.h instance_bpm.h instance_wdt.h instance_twim3.h instance_usart1.h instance_usbc.h instance_hmatrix.h instance_usart2.h instance_usart3.h instance_twim1.h instance_scif.h instance_adcife.h instance_twis1.h instance_eic.h instance_catb.h instance_tc1.h instance_pevc.h instance_twim2.h instance_hcache.h instance_twim0.h instance_gloc.h instance_usart0.h instance_lcdca.h instance_hflashc.h instance_spi.h instance_acifc.h instance_bscif.h instance_ast.h instance_tc0.h instance_smap.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc4c.h pio_sam4ls4c.h pio_sam4lc2b.h pio_sam4lc2a.h pio_sam4lc8c.h pio_sam4ls4a.h pio_sam4lc8b.h pio_sam4lc2c.h pio_sam4ls8a.h pio_sam4ls2b.h pio_sam4lc8a.h pio_sam4ls8c.h pio_sam4lc4b.h pio_sam4ls4b.h pio_sam4ls8b.h pio_sam4ls2c.h pio_sam4ls2a.h pio_sam4lc4a.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_pm.h component_hcache.h component_abdacb.h component_scif.h component_eic.h component_picouart.h component_aesa.h component_freqm.h component_twis.h component_twim.h component_trng.h component_gloc.h component_chipid.h component_pdca.h component_smap.h component_tc.h component_ast.h component_wdt.h component_flashcalw.h component_gpio.h component_iisc.h component_crccu.h component_dacc.h component_parc.h component_bpm.h component_spi.h component_acifc.h component_lcdca.h component_adcife.h component_usart.h component_pevc.h component_usbc.h component_catb.h component_hmatrixb.h component_bscif.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/ast
    ../../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../../../sam/boards/sam4l8_xplained_pro/: init.c sam4l8_xplained_pro.h led.h
