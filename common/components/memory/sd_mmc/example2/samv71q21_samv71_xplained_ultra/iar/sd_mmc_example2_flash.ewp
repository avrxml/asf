# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SD_MMC_ENABLE; __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../../sam/utils/fpu; ../../../../../../services/serial; ..; ../../../../../../services/ioport; ../../../../../../../sam/drivers/mpu; ../../../../../../utils; ../../../../../../../sam/utils/cmsis/samv71/source/templates; ../../../../../../../sam/boards/samv71_xplained_ultra; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../services/serial/sam_uart; ../../../../../../boards; ../../../../../../../sam/drivers/rtc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/xdmac; ../../../../../../../sam/drivers/hsmci; ../../../../../../services/storage/ctrl_access; ../../../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/samv71
    ../../../../../../services/clock/samv71/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_protocol.h sd_mmc_mem.h
  group common/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common/components/memory/sd_mmc/example2/samv71q21_samv71_xplained_ultra
    ../: conf_clock.h conf_board.h conf_sd_mmc.h conf_example.h conf_uart_serial.h
  group common/components/memory/sd_mmc/example2/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/xdmac
    ../../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../../sam/boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../../sam/utils/cmsis/samv71/include/: samv71n19.h samv71j20.h samv71q19.h samv71j21b.h samv71q19b.h samv71n20.h samv71j19.h samv71n19b.h samv71n21b.h samv71q20.h samv71n20b.h samv71q21b.h samv71j19b.h samv71.h samv71q21.h samv71q20b.h samv71j21.h samv71n21.h samv71j20b.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../../sam/utils/cmsis/samv71/include/component/: gpbr.h qspi.h rswdt.h efc.h hsmci.h utmi.h usbhs.h pio.h spi.h icm.h matrix.h rtc.h twihs.h pmc.h ssc.h aes.h xdmac.h i2sc.h pwm.h mcan.h uart.h tc.h rtt.h wdt.h dacc.h sdramc.h gmac.h chipid.h acc.h isi.h rstc.h usart.h afec.h trng.h supc.h smc.h mlb.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../../sam/utils/cmsis/samv71/include/instance/: spi0.h gmac.h efc.h uart3.h spi1.h twihs2.h hsmci.h pioa.h rswdt.h usart2.h usart0.h pwm0.h smc.h rstc.h mcan1.h afec1.h qspi.h trng.h utmi.h acc.h dacc.h tc2.h sdramc.h rtc.h pwm1.h twihs1.h afec0.h usbhs.h mcan0.h pmc.h rtt.h matrix.h uart4.h icm.h tc1.h gpbr.h piob.h i2sc1.h uart1.h piod.h wdt.h twihs0.h aes.h uart0.h chipid.h tc3.h mlb.h xdmac.h ssc.h isi.h tc0.h usart1.h pioc.h uart2.h i2sc0.h pioe.h supc.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71q21b.h samv71n20b.h samv71q21.h samv71j20.h samv71j21b.h samv71q19b.h samv71j19.h samv71j21.h samv71q20b.h samv71n19b.h samv71n21.h samv71n20.h samv71j19b.h samv71n21b.h samv71n19.h samv71q19.h samv71q20.h samv71j20b.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
