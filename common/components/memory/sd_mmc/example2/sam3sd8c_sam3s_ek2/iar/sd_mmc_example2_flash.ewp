# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM3SD8C__; ARM_MATH_CM3=true; SD_MMC_ENABLE; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../services/serial; ../../../../../../services/ioport; ../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../../sam/drivers/pdc; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/sam3s_ek2; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../services/serial/sam_uart; ../../../../../../boards; ..; ../../../../../../../sam/drivers/rtc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/hsmci; ../../../../../../../sam/utils/cmsis/sam3s8/include; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam3s
    ../../../../../../services/clock/sam3s/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_protocol.h sd_mmc_mem.h
  group common/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common/components/memory/sd_mmc/example2/sam3sd8c_sam3s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_example.h
  group common/components/memory/sd_mmc/example2/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/boards/sam3s_ek2
    ../../../../../../../sam/boards/sam3s_ek2/: led.c init.c led.h sam3s_ek2.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c exceptions.h system_sam3sd8.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../../sam/utils/cmsis/sam3s8/include/: sam3s8b.h sam3sd8c.h sam3s8.h sam3sd8b.h sam3s8c.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_usart2.h instance_pioc.h instance_smc.h instance_pioa.h instance_adc.h instance_pmc.h instance_rtc.h instance_chipid.h instance_rstc.h instance_twi0.h instance_ssc.h instance_efc.h instance_pwm.h instance_rtt.h instance_dacc.h instance_udp.h instance_usart1.h instance_tc1.h instance_acc.h instance_uart0.h instance_spi.h instance_usart0.h instance_supc.h instance_tc0.h instance_crccu.h instance_wdt.h instance_piob.h instance_uart1.h instance_gpbr.h instance_hsmci.h instance_matrix.h instance_twi1.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3s8b.h pio_sam3sd8c.h pio_sam3s8c.h pio_sam3sd8b.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_acc.h component_rstc.h component_gpbr.h component_rtt.h component_uart.h component_pio.h component_matrix.h component_spi.h component_crccu.h component_wdt.h component_pwm.h component_ssc.h component_tc.h component_supc.h component_pmc.h component_usart.h component_efc.h component_smc.h component_dacc.h component_udp.h component_pdc.h component_rtc.h component_chipid.h component_twi.h component_adc.h component_hsmci.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
