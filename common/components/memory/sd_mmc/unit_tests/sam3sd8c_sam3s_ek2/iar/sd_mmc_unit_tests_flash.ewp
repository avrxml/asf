# IAR project sd_mmc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3SD8C__; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../..; ../../../../../../services/serial/sam_uart; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../services/serial; ../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../../sam/drivers/pdc; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/sam3s_ek2; ../../../../../../services/gpio; ..; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/hsmci; ../../../../../../../sam/utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/sd_mmc
    ../../../: sd_mmc.c sd_mmc.h sd_mmc_protocol.h
  group common/components/memory/sd_mmc/unit_tests
    ../../: unit_tests.c
  group common/components/memory/sd_mmc/unit_tests/sam3sd8c_sam3s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_test.h
  group common/components/memory/sd_mmc/unit_tests/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam3s
    ../../../../../../services/clock/sam3s/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/boards/sam3s_ek2
    ../../../../../../../sam/boards/sam3s_ek2/: led.c init.c led.h sam3s_ek2.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c exceptions.h system_sam3sd8.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../../sam/utils/cmsis/sam3s8/include/: sam3s8b.h sam3sd8c.h sam3s8.h sam3sd8b.h sam3s8c.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_usart2.h instance_pioc.h instance_smc.h instance_pioa.h instance_adc.h instance_pmc.h instance_rtc.h instance_chipid.h instance_rstc.h instance_ssc.h instance_efc.h instance_rtt.h instance_dacc.h instance_udp.h instance_usart1.h instance_tc1.h instance_acc.h instance_uart0.h instance_pwm.h instance_spi.h instance_usart0.h instance_supc.h instance_twi0.h instance_tc0.h instance_crccu.h instance_wdt.h instance_piob.h instance_uart1.h instance_gpbr.h instance_hsmci.h instance_matrix.h instance_twi1.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3s8b.h pio_sam3sd8c.h pio_sam3s8c.h pio_sam3sd8b.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_acc.h component_crccu.h component_rstc.h component_rtt.h component_uart.h component_efc.h component_matrix.h component_spi.h component_wdt.h component_gpbr.h component_pwm.h component_ssc.h component_tc.h component_supc.h component_pmc.h component_usart.h component_pio.h component_smc.h component_dacc.h component_udp.h component_pdc.h component_rtc.h component_chipid.h component_twi.h component_adc.h component_hsmci.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
