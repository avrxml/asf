# IAR project sd_mmc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM3N_EK; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../..; ..; ../../../../../../services/serial/sam_uart; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../services/serial; ../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../sam/drivers/spi; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/sam3n_ek; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam3n_ek
    ../../../../../../../sam/boards/sam3n_ek/: led.c init.c led.h sam3n_ek.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c exceptions.h system_sam3n.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../../sam/utils/cmsis/sam3n/include/: sam3n2a.h sam3n1a.h sam3n2c.h sam3n1c.h sam3n4b.h sam3n.h sam3n2b.h sam3n4c.h sam3n4a.h sam3n1b.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n2c.h pio_sam3n2a.h pio_sam3n4a.h pio_sam3n1b.h pio_sam3n4c.h pio_sam3n2b.h pio_sam3n1a.h pio_sam3n1c.h pio_sam3n4b.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_matrix.h instance_dacc.h instance_adc.h instance_rstc.h instance_efc.h instance_gpbr.h instance_wdt.h instance_pmc.h instance_supc.h instance_twi0.h instance_spi.h instance_rtt.h instance_usart0.h instance_tc0.h instance_chipid.h instance_uart1.h instance_pioa.h instance_pwm.h instance_pioc.h instance_usart1.h instance_tc1.h instance_rtc.h instance_uart0.h instance_twi1.h instance_piob.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../../sam/utils/cmsis/sam3n/include/component/: component_rstc.h component_wdt.h component_dacc.h component_usart.h component_pmc.h component_pio.h component_matrix.h component_adc.h component_uart.h component_supc.h component_pwm.h component_chipid.h component_pdc.h component_tc.h component_efc.h component_rtt.h component_twi.h component_spi.h component_rtc.h component_gpbr.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h
  group common/components/memory/sd_mmc/unit_tests
    ../../: unit_tests.c
  group common/components/memory/sd_mmc/unit_tests/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_test.h conf_spi_master.h
  group common/components/memory/sd_mmc/unit_tests/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/sam3n
    ../../../../../../services/clock/sam3n/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../boards/: board.h
