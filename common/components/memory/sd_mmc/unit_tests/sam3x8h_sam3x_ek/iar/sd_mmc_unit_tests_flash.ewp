# IAR project sd_mmc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../..; ../../../../../../services/serial/sam_uart; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/boards/sam3x_ek; ../../../../../../../sam/utils/cmsis/sam3x/source/templates; ..; ../../../../../../services/serial; ../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/drivers/dmac; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/hsmci; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8c.h sam3x8e.h sam3a4c.h sam3x4c.h sam3x4e.h sam3x8h.h sam3a8c.h sam3xa.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../../sam/utils/cmsis/sam3x/include/component/: component_pwm.h component_rtt.h component_rtc.h component_spi.h component_dmac.h component_uotghs.h component_gpbr.h component_pmc.h component_trng.h component_smc.h component_chipid.h component_efc.h component_dacc.h component_hsmci.h component_emac.h component_tc.h component_pdc.h component_uart.h component_rstc.h component_adc.h component_can.h component_supc.h component_pio.h component_usart.h component_wdt.h component_sdramc.h component_ssc.h component_twi.h component_matrix.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_piob.h instance_tc0.h instance_tc1.h instance_pwm.h instance_trng.h instance_can1.h instance_pmc.h instance_usart2.h instance_smc.h instance_usart0.h instance_rtc.h instance_sdramc.h instance_adc.h instance_twi1.h instance_spi1.h instance_can0.h instance_matrix.h instance_dmac.h instance_emac.h instance_usart3.h instance_efc1.h instance_dacc.h instance_wdt.h instance_usart1.h instance_pioe.h instance_tc2.h instance_rtt.h instance_spi0.h instance_twi0.h instance_gpbr.h instance_ssc.h instance_supc.h instance_efc0.h instance_pioc.h instance_piof.h instance_pioa.h instance_chipid.h instance_piod.h instance_rstc.h instance_uart.h instance_hsmci.h instance_uotghs.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3a4c.h pio_sam3x8h.h pio_sam3x4c.h pio_sam3x8c.h pio_sam3x4e.h pio_sam3x8e.h pio_sam3a8c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/dmac
    ../../../../../../../sam/drivers/dmac/: dmac.c dmac.h
  group sam/boards/sam3x_ek
    ../../../../../../../sam/boards/sam3x_ek/: init.c led.c sam3x_ek.h led.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc.c sd_mmc.h sd_mmc_protocol.h
  group common/components/memory/sd_mmc/unit_tests
    ../../: unit_tests.c
  group common/components/memory/sd_mmc/unit_tests/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_test.h
  group common/components/memory/sd_mmc/unit_tests/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/sam3x
    ../../../../../../services/clock/sam3x/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
