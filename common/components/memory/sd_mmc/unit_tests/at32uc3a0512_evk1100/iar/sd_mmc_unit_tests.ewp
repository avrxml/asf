# IAR project sd_mmc_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../boards; ../../../../../../../avr32/boards; ../../../../../../services/spi/uc3_spi; ../../../../../../services/serial; ../../../../../../../avr32/utils; ../../../../../../../avr32/boards/evk1100; ../../../../../../../avr32/drivers/gpio; ../../../../../../utils; ../../../../../../../avr32/drivers/spi; ../../../../../../services/clock; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../services/delay; ../..; ../../../../../../services/serial/uc3_usart; ../../../../../../services/spi; ..; ../../../../../../../avr32/drivers/usart; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/ioport; ../../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc.c sd_mmc_spi.h sd_mmc_protocol.h sd_mmc.h
  group common/components/memory/sd_mmc/unit_tests
    ../../: unit_tests.c
  group common/components/memory/sd_mmc/unit_tests/at32uc3a0512_evk1100
    ../: conf_clock.h conf_test.h conf_board.h conf_sd_mmc.h conf_usart_serial.h conf_spi_master.h
  group common/components/memory/sd_mmc/unit_tests/at32uc3a0512_evk1100/iar
    ./: asf.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../services/serial/uc3_usart/: usart_serial.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/uc3a0_a1
    ../../../../../../services/clock/uc3a0_a1/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../services/ioport/uc3/: ioport.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/boards
    ../../../../../../boards/: board.h
  group avr32/boards/evk1100
    ../../../../../../../avr32/boards/evk1100/: led.c init.c evk1100.h led.h
  group avr32/drivers/spi
    ../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../avr32/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
