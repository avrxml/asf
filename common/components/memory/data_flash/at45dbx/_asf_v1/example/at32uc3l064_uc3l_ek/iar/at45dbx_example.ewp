# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/utils/debug; ../../../../../../../../../avr32/boards/uc3l_ek; ../../../../../../../../boards; ../../..; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/utils; ../../../../../../../../utils; ../../../../../../../../../avr32/utils/preprocessor; ../..; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/flashcdw; ../../../../../../../../../avr32/drivers/intc; ../../../../../../../../../avr32/drivers/spi; ../../../../../../../../services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK; AT45DBX_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c sleep.h power_clocks_lib.h pm_uc3l.h
  group avr32/drivers/flashcdw
    ../../../../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/intc
    ../../../../../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../../../../avr32/utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group avr32/boards/uc3l_ek
    ../../../../../../../../../avr32/boards/uc3l_ek/: led.c led.h uc3l_ek.h
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../: at45dbx.c at45dbx_mem.c at45dbx_mem.h at45dbx.h
  group common/components/memory/data_flash/at45dbx/_asf_v1/example
    ../../: at45dbx_example.c conf_access.h conf_at45dbx.h
  group common/components/memory/data_flash/at45dbx/_asf_v1/example/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group common/services/storage/ctrl_access
    ../../../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../boards/: board.h
