<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at45dbx_unit_tests.ewp</path>
	</project>
</workspace>
