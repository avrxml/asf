# IAR project at45dbx_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../services/clock; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../services/spi; ../../../../../../../services/serial; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../xmega/utils; ..; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/usart; ../../../../../../../../xmega/boards; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../utils; ../../../../../../../services/serial/xmega_usart; ../../../../../../../services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/boards/xmega_b1_xplained
    ../../../../../../../../xmega/boards/xmega_b1_xplained/: init.c led.h xmega_b1_xplained.h
  group xmega/drivers/usart
    ../../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/utils
    ../../../../../../../../xmega/utils/: assembler.h compiler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group xmega/utils/assembler
    ../../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/services/clock
    ../../../../../../../services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../../services/serial/xmega_usart/: usart_serial.h
  group common/services/spi
    ../../../../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common/components/memory/data_flash/at45dbx/unit_tests
    ../../: unit_tests.c
  group common/components/memory/data_flash/at45dbx/unit_tests/atxmega128b1_xmega_b1_xplained
    ../: conf_usart_spi.h conf_test.h conf_clock.h conf_board.h conf_at45dbx.h conf_usart_serial.h conf_spi_master.h
  group common/components/memory/data_flash/at45dbx/unit_tests/atxmega128b1_xmega_b1_xplained/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
