# IAR project at45dbx_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../avr32/boards/uc3c_ek; ../../../../../../../../avr32/drivers/spi; ../../../../../../../services/clock; ../../../../../../../services/serial/uc3_usart; ../../../../../../../services/spi; ../../../../../../../services/serial; ../../../../../../../boards; ../../..; ../../../../../../../../avr32/drivers/usart; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/gpio; ..; ../../../../../../../utils; ../../../../../../../services/spi/uc3_spi; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usart
    ../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/boards/uc3c_ek
    ../../../../../../../../avr32/boards/uc3c_ek/: led.c init.c uc3c_ek.h led.h
  group avr32/utils
    ../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../avr32/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/clock
    ../../../../../../../services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/uc3c
    ../../../../../../../services/clock/uc3c/: pll.c sysclk.c osc.c sysclk.h osc.h genclk.h pll.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../services/serial/uc3_usart/: usart_serial.h
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common/components/memory/data_flash/at45dbx/unit_tests
    ../../: unit_tests.c
  group common/components/memory/data_flash/at45dbx/unit_tests/at32uc3c0512c_uc3c_ek
    ../: conf_test.h conf_clock.h conf_board.h conf_at45dbx.h conf_usart_serial.h conf_spi_master.h
  group common/components/memory/data_flash/at45dbx/unit_tests/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
