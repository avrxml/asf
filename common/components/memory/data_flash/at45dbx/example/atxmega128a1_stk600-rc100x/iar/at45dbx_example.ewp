# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/boards/stk600/rc100x; ../../../../../../../services/spi/xmega_spi; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../services/spi; ..; ../../../../../../../boards; ../../../../../../../../xmega/utils/preprocessor; ../../..; ../../../../../../../../xmega/utils; ../../../../../../../../xmega/drivers/spi; ../../../../../../../services/clock; ../../../../../../../services/ioport; ../../../../../../../../xmega/boards; ../../../../../../../utils; ../../../../../../../services/gpio; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group xmega/boards/stk600/rc100x
    ../../../../../../../../xmega/boards/stk600/rc100x/: init.c led.h stk600_rc100x.h
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/utils
    ../../../../../../../../xmega/utils/: assembler.h compiler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../../xmega/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group xmega/utils/assembler
    ../../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/services/clock
    ../../../../../../../services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group common/components/memory/data_flash/at45dbx/example/atxmega128a1_stk600-rc100x
    ../: conf_data_flash_example.h conf_clock.h conf_board.h conf_at45dbx.h conf_spi_master.h
  group common/components/memory/data_flash/at45dbx/example/atxmega128a1_stk600-rc100x/iar
    ./: asf.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../boards/: board.h
