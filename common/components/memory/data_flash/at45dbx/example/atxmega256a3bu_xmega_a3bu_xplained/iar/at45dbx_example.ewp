# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../services/clock; ..; ../../../../../../../services/spi; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../xmega/utils; ../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/usart; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../../xmega/boards; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../utils; ../../../../../../../services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/usart
    ../../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../../../../xmega/utils/: assembler.h compiler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../../xmega/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/assembler
    ../../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/services/clock
    ../../../../../../../services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/spi
    ../../../../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group common/components/memory/data_flash/at45dbx/example/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_usart_spi.h conf_data_flash_example.h conf_board.h conf_at45dbx.h conf_clock.h
  group common/components/memory/data_flash/at45dbx/example/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../boards/: board.h
