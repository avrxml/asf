<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at45dbx_example.ewp</path>
	</project>
</workspace>
