<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at24cxx_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\at24cxx_example_sram.ewp</path>
	</project>
</workspace>
