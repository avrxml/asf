# IAR project at24cxx_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMP16C_0 Atmel ATSAM4CMP16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4CMP16C_0__; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/boards/sam4cmp_db; ../../..; ../../../../../../../services/serial; ..; ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../..; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../services/twi; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../services/ioport; ../../../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at24cxx_unit_tests_flash.bin
  ILINK.IlinkOutputFile: at24cxx_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cmp16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../../services/clock/sam4cm/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../../services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/eeprom/at24cxx
    ../../../: at24cxx.c at24cxx.h
  group common/components/memory/eeprom/at24cxx/unit_tests
    ../../: unit_tests.c
  group common/components/memory/eeprom/at24cxx/unit_tests/sam4cmp16c_sam4cmp_db
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h
  group common/components/memory/eeprom/at24cxx/unit_tests/sam4cmp16c_sam4cmp_db/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_0.h sam4cmp8c_0.h sam4cms4c_1.h sam4cms16c_1.h sam4cmp16c_0.h sam4cmp8c_1.h sam4cms4c_0.h sam4cm.h system_sam4cm.h sam4cms8c_1.h sam4cms16c_0.h sam4cmp16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: usart0.h cmcc0.h efc.h smc1.h wdt.h ipc1.h uart1.h spi0.h rtc.h matrix0.h chipid.h usart3.h adc.h usart2.h tc1.h tc0.h rswdt.h gpbr.h twi1.h ipc0.h pioa.h pmc.h pioc.h uart0.h usart1.h matrix1.h rstc.h twi0.h supc.h smc0.h rtt.h trng.h slcdc.h cmcc1.h piob.h pwm.h icm.h spi1.h aes.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: pwm.h gpbr.h tc.h adc.h chipid.h twi.h matrix.h rswdt.h rstc.h efc.h slcdc.h rtc.h trng.h rtt.h supc.h pdc.h spi.h pio.h smc.h pmc.h uart.h aes.h icm.h usart.h wdt.h ipc.h cmcc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cms4c.h sam4cmp16c.h sam4cmp8c.h sam4cms16c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/boards/sam4cmp_db
    ../../../../../../../../sam/boards/sam4cmp_db/: init.c sam4cmp_db.h led.h
