# IAR project at24cxx_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4C_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../../sam/boards/sam4c_ek; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../..; ../../../../../../../services/serial; ../../../../../../../../sam/utils/cmsis/sam4c/source/templates; ..; ../..; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../services/twi; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam4c/include; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at24cxx_unit_tests_sram.bin
  ILINK.IlinkOutputFile: at24cxx_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../../../sam/utils/cmsis/sam4c/include/: sam4c32c_0.h sam4c8c_1.h sam4c.h sam4c16c_0.h sam4c32e_1.h sam4c4c_0.h sam4c32e_0.h sam4c4c_1.h sam4c32c_1.h system_sam4c.h sam4c8c_0.h sam4c16c_1.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_matrix1.h instance_ipc1.h instance_adc.h instance_aes.h instance_uotghs.h instance_pwm.h instance_wdt.h instance_efc.h instance_uart0.h instance_tc1.h instance_icm.h instance_efc0.h instance_pmc.h instance_rstc.h instance_matrix0.h instance_piob.h instance_gpbr.h instance_supc.h instance_twi0.h instance_uart1.h instance_tc0.h instance_cmcc0.h instance_usart1.h instance_spi0.h instance_rswdt.h instance_pioa.h instance_usart3.h instance_pioc.h instance_efc1.h instance_twi1.h instance_smc1.h instance_rtt.h instance_spi1.h instance_chipid.h instance_ipc0.h instance_usart0.h instance_cmcc1.h instance_slcdc.h instance_usart2.h instance_rtc.h instance_usart4.h instance_trng.h instance_smc0.h instance_piod.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../../../sam/utils/cmsis/sam4c/include/component/: component_gpbr.h component_trng.h component_chipid.h component_rswdt.h component_supc.h component_tc.h component_pwm.h component_adc.h component_icm.h component_ipc.h component_slcdc.h component_cmcc.h component_uotghs.h component_pio.h component_smc.h component_matrix.h component_spi.h component_efc.h component_rstc.h component_usart.h component_pdc.h component_rtc.h component_aes.h component_uart.h component_wdt.h component_twi.h component_rtt.h component_pmc.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c16c.h pio_sam4c4c.h pio_sam4c32c.h pio_sam4c8c.h pio_sam4c32e.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/boards/sam4c_ek
    ../../../../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/components/memory/eeprom/at24cxx
    ../../../: at24cxx.c at24cxx.h
  group common/components/memory/eeprom/at24cxx/unit_tests
    ../../: unit_tests.c
  group common/components/memory/eeprom/at24cxx/unit_tests/sam4c16c_sam4c_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h
  group common/components/memory/eeprom/at24cxx/unit_tests/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4c
    ../../../../../../../services/clock/sam4c/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/twi
    ../../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../../services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../boards/: board.h
