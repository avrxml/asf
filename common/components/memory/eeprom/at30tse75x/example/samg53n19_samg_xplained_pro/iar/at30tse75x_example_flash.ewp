# IAR project at30tse75x_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/drivers/efc; ../../../../../../../../sam/utils/fpu; ../../..; ../../../../../../../services/serial; ../../../../../../../../sam/boards/samg53_xplained_pro; ../../../../../../../../sam/drivers/supc; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../services/twi; ../../../../../../../../sam/utils/cmsis/samg/samg53/include; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils/cmsis/samg/samg53/source/templates; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../services/serial/sam_uart; ../../../../../../../boards; ..; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_example_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../../services/clock/samg/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../../services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/eeprom/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group common/components/memory/eeprom/at30tse75x/example
    ../../: at30tes_example.c
  group common/components/memory/eeprom/at30tse75x/example/samg53n19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group common/components/memory/eeprom/at30tse75x/example/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../../../../sam/utils/cmsis/samg/samg53/source/templates/: exceptions.c system_samg53.c system_samg53.h exceptions.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../../../../sam/utils/cmsis/samg/samg53/include/: samg53g19.h samg53n19.h samg53.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../../../../sam/utils/cmsis/samg/samg53/include/instance/: instance_tc0.h instance_chipid.h instance_pdmic1.h instance_gpbr.h instance_tc1.h instance_rtt.h instance_matrix.h instance_supc.h instance_rtc.h instance_mem2mem.h instance_efc.h instance_usart.h instance_twi1.h instance_uart1.h instance_rstc.h instance_pioa.h instance_twi2.h instance_i2sc0.h instance_wdt.h instance_pmc.h instance_uart0.h instance_piob.h instance_adc.h instance_twi0.h instance_i2sc1.h instance_pdmic0.h instance_spi.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../../../../sam/utils/cmsis/samg/samg53/include/component/: component_usart.h component_rtt.h component_tc.h component_pdc.h component_supc.h component_pmc.h component_uart.h component_spi.h component_pio.h component_chipid.h component_twi.h component_twihs.h component_gpbr.h component_pdmic.h component_i2sc.h component_rstc.h component_efc.h component_wdt.h component_adc.h component_mem2mem.h component_rtc.h component_matrix.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../../../../sam/utils/cmsis/samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/samg53_xplained_pro
    ../../../../../../../../sam/boards/samg53_xplained_pro/: board_init.c samg53_xplained_pro.h led.h
