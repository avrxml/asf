<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at30tse75x_example_flash.ewp</path>
	</project>
</workspace>
