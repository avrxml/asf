# IAR project at30tse75x_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/cmsis/sam4n/include; ../../../../../../../../sam/boards/sam4n_xplained_pro; ../../../../../../../../sam/utils/cmsis/sam4n/source/templates; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../..; ../../../../../../../services/serial; ../../../../../../../utils; ..; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../services/twi; ../../../../../../../services/serial/sam_uart; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_unit_tests_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4n
    ../../../../../../../services/clock/sam4n/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../../services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/memory/eeprom/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group common/components/memory/eeprom/at30tse75x/unit_tests
    ../../: unit_tests.c
  group common/components/memory/eeprom/at30tse75x/unit_tests/sam4n16c_sam4n_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h
  group common/components/memory/eeprom/at30tse75x/unit_tests/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4n/source/templates/: exceptions.c system_sam4n.c exceptions.h system_sam4n.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../../../../sam/utils/cmsis/sam4n/include/: sam4n16b.h sam4n8b.h sam4n16c.h sam4n8a.h sam4n8c.h sam4n.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4n/include/pio/: pio_sam4n8b.h pio_sam4n16c.h pio_sam4n8c.h pio_sam4n16b.h pio_sam4n8a.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../../../../sam/utils/cmsis/sam4n/include/component/: component_supc.h component_tc.h component_rtt.h component_uart.h component_pwm.h component_pmc.h component_matrix.h component_chipid.h component_pio.h component_gpbr.h component_pdc.h component_wdt.h component_rstc.h component_efc.h component_twi.h component_rtc.h component_spi.h component_adc.h component_dacc.h component_usart.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4n/include/instance/: instance_rstc.h instance_pwm.h instance_uart0.h instance_dacc.h instance_twi1.h instance_wdt.h instance_gpbr.h instance_rtt.h instance_matrix.h instance_spi.h instance_twi2.h instance_rtc.h instance_efc.h instance_twi0.h instance_pioc.h instance_pioa.h instance_usart2.h instance_uart3.h instance_tc0.h instance_usart0.h instance_pmc.h instance_piob.h instance_adc.h instance_uart1.h instance_supc.h instance_uart2.h instance_chipid.h instance_usart1.h instance_tc1.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../../../../sam/boards/sam4n_xplained_pro/: init.c led.h sam4n_xplained_pro.h
