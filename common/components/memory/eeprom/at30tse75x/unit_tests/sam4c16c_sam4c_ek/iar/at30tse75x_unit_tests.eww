<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at30tse75x_unit_tests_flash.ewp</path>
	</project>
</workspace>
