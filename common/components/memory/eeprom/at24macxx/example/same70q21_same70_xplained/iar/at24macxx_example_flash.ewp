# IAR project at24macxx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/cmsis/same70/include; ../../../../../../../../sam/utils/fpu; ../../../../../../../services/gpio; ../../../../../../../services/serial; ../../../../../../../../sam/drivers/mpu; ../../../../../../../utils; ..; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../../sam/drivers/twihs; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/same70_xplained; ../../../../../../../services/twi; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../..; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at24macxx_example_flash.bin
  ILINK.IlinkOutputFile: at24macxx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../sam/utils/cmsis/same70/include/: same70q21b.h same70n21b.h same70n21.h same70j21b.h same70j20b.h same70q21.h same70j19b.h same70q20.h same70q19.h same70n20b.h same70q20b.h same70j20.h same70.h same70j19.h same70n19b.h same70n20.h same70q19b.h same70n19.h same70j21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../sam/utils/cmsis/same70/include/instance/: afec1.h hsmci.h uart3.h aes.h acc.h smc.h i2sc1.h piob.h i2sc0.h gpbr.h spi0.h rswdt.h mcan0.h isi.h uart1.h piod.h usart2.h tc2.h ssc.h pwm1.h trng.h supc.h mcan1.h qspi.h usbhs.h dacc.h usart0.h uart4.h sdramc.h twihs2.h twihs0.h tc3.h pwm0.h wdt.h gmac.h uart2.h tc1.h pmc.h matrix.h rtc.h usart1.h afec0.h twihs1.h tc0.h pioa.h icm.h rtt.h efc.h spi1.h xdmac.h rstc.h pioc.h chipid.h utmi.h pioe.h uart0.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../sam/utils/cmsis/same70/include/component/: efc.h trng.h gpbr.h wdt.h rtc.h utmi.h chipid.h usart.h pio.h hsmci.h pmc.h supc.h i2sc.h dacc.h xdmac.h rswdt.h tc.h rtt.h gmac.h afec.h ssc.h isi.h mcan.h sdramc.h pwm.h aes.h qspi.h matrix.h rstc.h spi.h smc.h usbhs.h icm.h twihs.h acc.h uart.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70n20b.h same70q21.h same70n20.h same70n19.h same70n19b.h same70j20.h same70j19.h same70q19.h same70j20b.h same70j21.h same70j19b.h same70q20.h same70n21.h same70q21b.h same70q19b.h same70j21b.h same70q20b.h same70n21b.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/twihs
    ../../../../../../../../sam/drivers/twihs/: twihs.c twihs.h
  group sam/boards/same70_xplained
    ../../../../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
  group common/components/memory/eeprom/at24macxx
    ../../../: at24macxx.c at24macxx.h
  group common/components/memory/eeprom/at24macxx/example
    ../../: at24macxx_example.c
  group common/components/memory/eeprom/at24macxx/example/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group common/components/memory/eeprom/at24macxx/example/same70q21_same70_xplained/iar
    ./: asf.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/same70
    ../../../../../../../services/clock/same70/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/twi
    ../../../../../../../services/twi/: twihs_slave.h twihs_master.h
  group common/services/twi/sam_twihs
    ../../../../../../../services/twi/sam_twihs/: twihs_master.h twihs_slave.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../boards/: board.h
