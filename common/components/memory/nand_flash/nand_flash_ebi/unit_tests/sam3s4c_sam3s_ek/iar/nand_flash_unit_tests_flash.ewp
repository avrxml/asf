# IAR project nand_flash_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/utils/preprocessor; ../..; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/drivers/ebi/smc; ..; ../../../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../../../../sam/boards; ../../../../../../../utils; ../../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../../../../../../../sam/boards/sam3s_ek; ../../../../../../../services/clock; ../../../../../../../../sam/drivers/matrix; ../../../../../../../utils/stdio/stdio_serial; ../../..; ../../../ftl_lib; ../../../../../../../services/gpio; ../../../../../../../services/storage/ecc_hamming; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../services/serial/sam_uart; ../../../../../../../boards; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/pmc; ../../../../../../../services/serial; ../../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nand_flash_unit_tests_flash.bin
  ILINK.IlinkOutputFile: nand_flash_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../: nand_flash_raw_smc.c nand_flash_model.c nand_flash_spare_scheme.c nand_flash_ecc_sw.c nand_flash_raw.h nand_flash_spare_scheme.h nand_flash_ecc.h nand_flash_common.h nand_flash_model.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../ftl_lib/: nand_flash_mem.c nand_flash_mem.h nand_flash_management.h nand_flash_translation.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../ftl_lib/iar/: lib_nand_flash_cortexm3.a
  group common/components/memory/nand_flash/nand_flash_ebi/unit_tests
    ../../: unit_tests.c
  group common/components/memory/nand_flash/nand_flash_ebi/unit_tests/sam3s4c_sam3s_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h conf_access.h conf_nf.h
  group common/components/memory/nand_flash/nand_flash_ebi/unit_tests/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/storage/ecc_hamming
    ../../../../../../../services/storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/storage/ctrl_access
    ../../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam3s
    ../../../../../../../services/clock/sam3s/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/matrix
    ../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/ebi/smc
    ../../../../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/boards/sam3s_ek
    ../../../../../../../../sam/boards/sam3s_ek/: led.c init.c led.h sam3s_ek.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c system_sam3s.h exceptions.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../../../../../../sam/utils/cmsis/sam3s/include/: sam3s4b.h sam3s1b.h sam3s4a.h sam3s1c.h sam3s.h sam3s1a.h sam3s2b.h sam3s4c.h sam3s2a.h sam3s2c.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../../../../../../sam/utils/cmsis/sam3s/include/component/: component_rtc.h component_supc.h component_uart.h component_usart.h component_smc.h component_crccu.h component_ssc.h component_hsmci.h component_rstc.h component_pwm.h component_pdc.h component_dacc.h component_wdt.h component_pmc.h component_efc.h component_adc.h component_spi.h component_chipid.h component_acc.h component_twi.h component_pio.h component_gpbr.h component_tc.h component_rtt.h component_matrix.h component_udp.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3s/include/instance/: instance_adc.h instance_smc.h instance_tc0.h instance_rtt.h instance_twi0.h instance_usart1.h instance_supc.h instance_acc.h instance_pmc.h instance_tc1.h instance_crccu.h instance_uart1.h instance_pioa.h instance_efc.h instance_spi.h instance_wdt.h instance_hsmci.h instance_udp.h instance_rstc.h instance_pwm.h instance_gpbr.h instance_usart0.h instance_uart0.h instance_twi1.h instance_pioc.h instance_dacc.h instance_rtc.h instance_piob.h instance_chipid.h instance_matrix.h instance_ssc.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3s/include/pio/: pio_sam3s2b.h pio_sam3s4a.h pio_sam3s2a.h pio_sam3s2c.h pio_sam3s1b.h pio_sam3s1a.h pio_sam3s4b.h pio_sam3s1c.h pio_sam3s4c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
