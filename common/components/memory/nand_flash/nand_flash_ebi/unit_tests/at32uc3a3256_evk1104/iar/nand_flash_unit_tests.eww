<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nand_flash_unit_tests.ewp</path>
	</project>
</workspace>
