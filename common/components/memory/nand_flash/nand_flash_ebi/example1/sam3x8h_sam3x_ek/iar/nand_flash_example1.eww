<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nand_flash_example1_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\nand_flash_example1_sram.ewp</path>
	</project>
</workspace>
