<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nand_flash_example2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\nand_flash_example2_sram.ewp</path>
	</project>
</workspace>
