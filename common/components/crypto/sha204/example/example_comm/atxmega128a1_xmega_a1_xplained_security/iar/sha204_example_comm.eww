<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sha204_example_comm.ewp</path>
	</project>
</workspace>
