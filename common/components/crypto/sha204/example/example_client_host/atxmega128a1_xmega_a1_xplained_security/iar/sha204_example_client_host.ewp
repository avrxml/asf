# IAR project sha204_example_client_host.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SECURITY_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/utils; ../../../..; ../../../../xmega_sha204; ../../../../../../../services/gpio; ../../../../../../../services/serial; ../../../../../../../services/ioport; ../../../../../../../services/serial/xmega_usart; ../../../../../../../../xmega/drivers/usart; ../../../../../../../services/sleepmgr; ../../../../../../../utils; ../../../example_utilities_log; ../../../../../../../services/clock; ../../../../../../../../xmega/boards/xmega_a1_xplained; ../..; ../../../../../../../../xmega/boards; ../../../../../../../services/twi; ../../../example_utilities_led; ../../../../../../../boards/security_xplained; ../../../../../../../../xmega/drivers/twi; ../../../../../../../boards; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/sleep; ../../../../../../../../xmega/drivers/cpu; ..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SECURITY_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/components/crypto/sha204
    ../../../../: sha204_comm.c sha204_command_marshaling.c sha204_i2c.c sha204_comm.h sha204_command_marshaling.h sha204_config.h sha204_lib_return_codes.h sha204_physical.h
  group common/components/crypto/sha204/xmega_sha204
    ../../../../xmega_sha204/: sha204_timer.c sha204_timer.h
  group common/components/crypto/sha204/example/example_utilities_log
    ../../../example_utilities_log/: sha204_example_log.c sha204_example_log.h
  group common/components/crypto/sha204/example/example_utilities_led
    ../../../example_utilities_led/: sha204_example_led.c sha204_example_led.h
  group common/components/crypto/sha204/example/example_client_host
    ../../: sha204_example_client_host.c
  group common/components/crypto/sha204/example/example_client_host/atxmega128a1_xmega_a1_xplained_security
    ../: conf_atsha204.h conf_board.h conf_sleepmgr.h conf_twim.h conf_usart_serial.h conf_clock.h
  group common/components/crypto/sha204/example/example_client_host/atxmega128a1_xmega_a1_xplained_security/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group common/boards/security_xplained
    ../../../../../../../boards/security_xplained/: security_xplained.c security_xplained.h
  group common/services/clock
    ../../../../../../../services/clock/: osc.h sysclk.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../../services/serial/xmega_usart/: usart_serial.h
  group common/services/twi
    ../../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../../../../services/twi/xmega_twi/: twi_master.h twi_slave.h
  group common/services/gpio
    ../../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr8.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../../../../xmega/boards/xmega_a1_xplained/: init.c led.h xmega_a1_xplained.h
  group xmega/drivers/usart
    ../../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/twi
    ../../../../../../../../xmega/drivers/twi/: twim.c twis.c twi_common.h twis.h twim.h
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/utils
    ../../../../../../../../xmega/utils/: assembler.h compiler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group xmega/utils/assembler
    ../../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
