<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sha204_unit_tests.ewp</path>
	</project>
</workspace>
