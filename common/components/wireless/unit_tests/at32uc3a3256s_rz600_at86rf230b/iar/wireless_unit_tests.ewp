# IAR project wireless_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=RZ600; UDD_ENABLE; EXT_BOARD=RZ600_AT86RF230B
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../services/usb/class/cdc/device; ../../../../../../avr32/drivers/usbb; ../../../../../../avr32/boards; ../../../../../services/spi/uc3_spi; ../../..; ../../../../../../avr32/drivers/pm; ../..; ../../../../../services/clock; ../../../../../utils/stdio/stdio_usb; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../services/sleepmgr; ../../../../../utils; ../../../../../../avr32/boards/rz600; ../../../../../../avr32/drivers/spi; ../../../../../services/usb/class/cdc; ..; ../../../../../services/usb/udc; ../../../../../services/usb; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../services/spi; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/services/sleepmgr
    ../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../services/clock/uc3a3_a4/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/usb
    ../../../../../services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../services/usb/udc/: udc.c udc_desc.h udi.h udd.h udc.h
  group common/services/spi
    ../../../../../services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/components/wireless
    ../../../: at86rfx_driver.c at86rfx_driver.h
  group common/components/wireless/unit_tests
    ../../: unit_tests.c unit_tests.h
  group common/components/wireless/unit_tests/at32uc3a3256s_rz600_at86rf230b
    ../: conf_test.h conf_clock.h conf_at86rfx.h conf_sleepmgr.h conf_board.h conf_usb.h conf_spi_master.h
  group common/components/wireless/unit_tests/at32uc3a3256s_rz600_at86rf230b/iar
    ./: asf.h
  group common/components/wireless/at86rf230b
    ../../../at86rf230b/: at86rf230b.c at86rf230b.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/boards/rz600
    ../../../../../../avr32/boards/rz600/: led.c init.c led.h rz600.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usbb
    ../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
