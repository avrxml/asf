<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wireless_unit_tests.ewp</path>
	</project>
</workspace>
