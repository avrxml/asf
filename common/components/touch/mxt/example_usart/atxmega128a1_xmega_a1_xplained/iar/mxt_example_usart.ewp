# IAR project mxt_example_usart.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../services/gpio; ../../../../../../services/ioport; ../../../../../../services/delay; ../../../../../../../xmega/drivers/twi; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/utils; ../../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../../services/serial/xmega_usart; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../../../utils; ..; ../../../../../../utils/stdio/stdio_serial; ../../../../../../services/twi; ../../..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/components/touch/mxt
    ../../../: mxt_device.c mxt_device.h
  group common/components/touch/mxt/example_usart
    ../../: example_usart.c
  group common/components/touch/mxt/example_usart/atxmega128a1_xmega_a1_xplained
    ../: conf_mxt.h conf_clock.h conf_board.h conf_twim.h conf_example.h conf_usart_serial.h
  group common/components/touch/mxt/example_usart/atxmega128a1_xmega_a1_xplained/iar
    ./: asf.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../services/serial/xmega_usart/: usart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/twi
    ../../../../../../services/twi/: twi_slave.h twi_master.h
  group common/services/twi/xmega_twi
    ../../../../../../services/twi/xmega_twi/: twi_slave.h twi_master.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../../../xmega/boards/xmega_a1_xplained/: init.c led.h xmega_a1_xplained.h
  group xmega/drivers/twi
    ../../../../../../../xmega/drivers/twi/: twis.c twim.c twis.h twim.h twi_common.h
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/utils
    ../../../../../../../xmega/utils/: status_codes.h compiler.h assembler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
