<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mxt_example_usart.ewp</path>
	</project>
</workspace>
