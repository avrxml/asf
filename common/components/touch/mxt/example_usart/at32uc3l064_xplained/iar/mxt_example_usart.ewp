# IAR project mxt_example_usart.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../services/delay; ../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr32/boards/uc3_l0_xplained; ../../../../../../services/clock; ../../../../../../services/serial/uc3_usart; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../../avr32/boards; ../../../../../../../avr32/drivers/usart; ../../../../../../services/ioport; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../avr32/drivers/twim; ../../../../../../utils; ../../../../../../../avr32/drivers/flashcdw; ../../../../../../utils/stdio/stdio_serial; ..; ../../../../../../services/twi; ../../..; ../../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h dfll.h
  group common/services/clock/uc3l
    ../../../../../../services/clock/uc3l/: dfll.c osc.c sysclk.c genclk.h osc.h dfll.h sysclk.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../services/serial/uc3_usart/: usart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../services/ioport/uc3/: ioport.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/twi
    ../../../../../../services/twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../../../services/twi/uc3_twim/: twi_master.h
  group common/components/touch/mxt
    ../../../: mxt_device.c mxt_device.h
  group common/components/touch/mxt/example_usart
    ../../: example_usart.c
  group common/components/touch/mxt/example_usart/at32uc3l064_xplained
    ../: conf_mxt.h conf_clock.h conf_board.h conf_twim.h conf_example.h conf_usart_serial.h
  group common/components/touch/mxt/example_usart/at32uc3l064_xplained/iar
    ./: asf.h
  group common/boards
    ../../../../../../boards/: board.h
  group avr32/drivers/twim
    ../../../../../../../avr32/drivers/twim/: twim.c twim.h
  group avr32/drivers/flashcdw
    ../../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/usart
    ../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c uc3_l0_xplained.h led.h
  group avr32/utils
    ../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../avr32/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
