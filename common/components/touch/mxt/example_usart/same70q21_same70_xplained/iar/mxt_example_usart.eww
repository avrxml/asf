<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mxt_example_usart_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mxt_example_usart_sram.ewp</path>
	</project>
</workspace>
