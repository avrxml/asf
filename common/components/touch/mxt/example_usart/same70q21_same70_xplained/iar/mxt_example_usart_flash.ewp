# IAR project mxt_example_usart_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../services/serial/sam_uart; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/same70/include; ../../../../../../../sam/utils/fpu; ../../../../../../services/gpio; ../../../../../../services/serial; ../../../../../../../sam/drivers/mpu; ../../../../../../utils; ../../../../../../../sam/drivers/twihs; ../../../../../../services/clock; ../../../../../../../sam/boards; ..; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/same70_xplained; ../../../../../../services/twi; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../..; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mxt_example_usart_flash.bin
  ILINK.IlinkOutputFile: mxt_example_usart_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../sam/utils/cmsis/same70/include/: same70q20b.h same70j19.h same70q20.h same70n20.h same70j20.h same70j21b.h same70j21.h same70q21.h same70n21b.h same70n19.h same70q19b.h same70j19b.h same70n20b.h same70q21b.h same70n19b.h same70q19.h same70n21.h same70.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../sam/utils/cmsis/same70/include/instance/: rstc.h trng.h usbhs.h rswdt.h smc.h isi.h afec0.h icm.h gpbr.h qspi.h spi1.h uart4.h mcan0.h tc3.h piod.h rtt.h tc1.h xdmac.h aes.h dacc.h chipid.h hsmci.h efc.h sdramc.h uart1.h i2sc1.h pioc.h matrix.h tc2.h uart3.h usart1.h uart2.h pioe.h usart2.h supc.h acc.h twihs0.h pwm0.h i2sc0.h usart0.h pioa.h spi0.h wdt.h pmc.h utmi.h tc0.h twihs1.h gmac.h afec1.h twihs2.h rtc.h piob.h pwm1.h uart0.h mcan1.h ssc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../sam/utils/cmsis/same70/include/component/: matrix.h qspi.h twihs.h pmc.h tc.h i2sc.h chipid.h dacc.h pwm.h rtt.h ssc.h uart.h smc.h rswdt.h acc.h efc.h wdt.h afec.h isi.h gmac.h usbhs.h mcan.h sdramc.h xdmac.h utmi.h icm.h usart.h spi.h hsmci.h aes.h gpbr.h pio.h rtc.h rstc.h trng.h supc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70q19b.h same70n19b.h same70q21b.h same70q19.h same70j20b.h same70q20.h same70n21b.h same70n20.h same70j19b.h same70j20.h same70n21.h same70j21.h same70j21b.h same70n20b.h same70n19.h same70j19.h same70q21.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h stringz.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/twihs
    ../../../../../../../sam/drivers/twihs/: twihs.c twihs.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/same70
    ../../../../../../services/clock/same70/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/twi
    ../../../../../../services/twi/: twihs_slave.h twihs_master.h
  group common/services/twi/sam_twihs
    ../../../../../../services/twi/sam_twihs/: twihs_slave.h twihs_master.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/touch/mxt
    ../../../: mxt_device_1.c mxt_device_1.h
  group common/components/touch/mxt/example_usart
    ../../: example_usart.c
  group common/components/touch/mxt/example_usart/same70q21_same70_xplained
    ../: conf_mxt.h conf_uart_serial.h conf_clock.h conf_board.h conf_example.h
  group common/components/touch/mxt/example_usart/same70q21_same70_xplained/iar
    ./: asf.h
  group common/boards
    ../../../../../../boards/: board.h
