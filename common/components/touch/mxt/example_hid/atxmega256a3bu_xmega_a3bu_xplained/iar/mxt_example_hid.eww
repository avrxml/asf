<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mxt_example_hid.ewp</path>
	</project>
</workspace>
