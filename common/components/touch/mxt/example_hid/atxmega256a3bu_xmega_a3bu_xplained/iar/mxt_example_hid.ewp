# IAR project mxt_example_hid.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x1000
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../../xmega/drivers/pmic; ../../../../../../../xmega/utils; ../../../../../../services/gfx; ../../../../../../services/gpio; ../../../../../../../xmega/utils/preprocessor; ../..; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/drivers/nvm; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../..; ../../../../../../services/usb/class/hid/device/mouse; ../../../../../../services/clock; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../xmega/boards; ../../../../../../services/twi; ../../../../../../services/delay; ../../../../../display/ili9341; ../../../../../../../xmega/drivers/twi; ../../../../../../services/usb/class/hid/device; ../../../../../../../xmega/drivers/usb; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../services/usb/class/hid; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/components/touch/mxt
    ../../../: mxt_device.c mxt_device.h
  group common/components/touch/mxt/example_hid
    ../../: ui.c example_hid.c example_hid.h conf_usb.h ui.h conf_sysfont.h
  group common/components/touch/mxt/example_hid/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_mxt.h conf_usart_spi.h conf_ili9341.h conf_twim.h conf_board.h conf_sleepmgr.h conf_example.h conf_clock.h
  group common/components/touch/mxt/example_hid/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/components/display/ili9341
    ../../../../../display/ili9341/: ili9341.c ili9341_regs.h ili9341.h
  group common/services/usb
    ../../../../../../services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc.h udc_desc.h udi.h udd.h
  group common/services/usb/class/hid
    ../../../../../../services/usb/class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../../services/usb/class/hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../../services/usb/class/hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/gfx
    ../../../../../../services/gfx/: gfx_text.c gfx_generic.c gfx_ili9341_sdt028atft.c sysfont.c gfx_text.h gfx_generic.h gfx.h gfx_ili9341_sdt028atft.h sysfont.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/twi
    ../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../../../services/twi/xmega_twi/: twi_master.h twi_slave.h
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../boards/: board.h
  group xmega/drivers/twi
    ../../../../../../../xmega/drivers/twi/: twis.c twim.c twis.h twim.h twi_common.h
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/utils
    ../../../../../../../xmega/utils/: status_codes.h compiler.h assembler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
