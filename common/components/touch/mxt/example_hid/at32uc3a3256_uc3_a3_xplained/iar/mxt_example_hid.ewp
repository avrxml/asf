# IAR project mxt_example_hid.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; UDD_ENABLE; BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../avr32/boards; ../../../../../../../avr32/drivers/pdca; ../../../../../../../avr32/drivers/twim; ../../../../../../../avr32/drivers/usbb; ../../../../../../../avr32/drivers/pm; ../../../../../../../avr32/drivers/eic; ../../../../../../services/gfx; ../..; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/gpio; ..; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../../../../../../avr32/drivers/spi; ../../..; ../../../../../../services/usb/class/hid/device/mouse; ../../../../../../services/clock; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../services/twi; ../../../../../../../avr32/boards/uc3_a3_xplained; ../../../../../../services/delay; ../../../../../display/ili9341; ../../../../../../services/usb/class/hid/device; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/ioport; ../../../../../../services/spi/uc3_spi; ../../../../../../../avr32/utils/preprocessor; ../../../../../../services/usb/class/hid; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/gfx
    ../../../../../../services/gfx/: sysfont.c gfx_text.c gfx_generic.c gfx_ili9341_sdt028atft.c gfx_text.h gfx.h gfx_generic.h gfx_ili9341_sdt028atft.h sysfont.h
  group common/services/usb
    ../../../../../../services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../../services/usb/class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../../services/usb/class/hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../../services/usb/class/hid/device/mouse/: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc.h udc_desc.h udi.h udd.h
  group common/services/clock
    ../../../../../../services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/uc3a3_a4
    ../../../../../../services/clock/uc3a3_a4/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../services/ioport/uc3/: ioport.h
  group common/services/twi
    ../../../../../../services/twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../../../services/twi/uc3_twim/: twi_master.h
  group common/components/touch/mxt
    ../../../: mxt_device.c mxt_device.h
  group common/components/touch/mxt/example_hid
    ../../: ui.c example_hid.c conf_usb.h example_hid.h ui.h conf_sysfont.h
  group common/components/touch/mxt/example_hid/at32uc3a3256_uc3_a3_xplained
    ../: conf_mxt.h conf_ili9341.h conf_clock.h conf_board.h conf_sleepmgr.h conf_twim.h conf_example.h conf_spi_master.h
  group common/components/touch/mxt/example_hid/at32uc3a3256_uc3_a3_xplained/iar
    ./: asf.h
  group common/components/display/ili9341
    ../../../../../display/ili9341/: ili9341.c ili9341_regs.h ili9341.h
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../boards/: board.h
  group avr32/drivers/spi
    ../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/pm
    ../../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c pm.h power_clocks_lib.h sleep.h
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/twim
    ../../../../../../../avr32/drivers/twim/: twim.c twim.h
  group avr32/drivers/pdca
    ../../../../../../../avr32/drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/eic
    ../../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/usbb
    ../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_otg.h usbb_device.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_a3_xplained
    ../../../../../../../avr32/boards/uc3_a3_xplained/: init.c led.c uc3_a3_xplained.h led.h
  group avr32/utils
    ../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../avr32/utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
