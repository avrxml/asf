# IAR project mxt_example_hid_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; CONF_GFX_ILI9341_SDT028ATFT=1; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../services/gfx; ../../../../../../services/twi; ..; ../..; ../../../../../../../sam/drivers/spi; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../..; ../../../../../../services/usb/class/hid/device/mouse; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../services/delay; ../../../../../../../sam/drivers/udp; ../../../../../../services/gpio; ../../../../../../../sam/drivers/pdc; ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../display/ili9341; ../../../../../../../sam/utils; ../../../../../../services/usb/class/hid/device; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/boards/sam4s_xplained; ../../../../../../services/usb/class/hid; ../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mxt_example_hid_flash.bin
  ILINK.IlinkOutputFile: mxt_example_hid_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/gfx
    ../../../../../../services/gfx/: sysfont.c gfx_text.c gfx_generic.c gfx_ili9341_sdt028atft.c gfx_ili9341_sdt028atft.h gfx_generic.h gfx_text.h gfx.h sysfont.h
  group common/services/usb
    ../../../../../../services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc_desc.h udi.h udd.h udc.h
  group common/services/usb/class/hid
    ../../../../../../services/usb/class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../../services/usb/class/hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../../services/usb/class/hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam4s
    ../../../../../../services/clock/sam4s/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/twi
    ../../../../../../services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/components/touch/mxt
    ../../../: mxt_device.c mxt_device.h
  group common/components/touch/mxt/example_hid
    ../../: example_hid.c ui.c conf_usb.h ui.h example_hid.h conf_sysfont.h
  group common/components/touch/mxt/example_hid/sam4s16c_sam4s_xplained
    ../: conf_sleepmgr.h conf_twim.h conf_clock.h conf_board.h conf_spi_master.h conf_mxt.h conf_example.h conf_ili9341.h
  group common/components/touch/mxt/example_hid/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group common/components/display/ili9341
    ../../../../../display/ili9341/: ili9341.c ili9341_regs.h ili9341.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/drivers/twi
    ../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: led.c init.c led.h sam4s_xplained.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s16c.h sam4sd32c.h sam4s2b.h sam4s4b.h system_sam4s.h sam4sd32b.h sam4sd16b.h sam4s16b.h sam4sa16c.h sam4s8b.h sam4sd16c.h sam4s.h sam4s8c.h sam4sa16b.h sam4s4c.h sam4s2a.h sam4s4a.h sam4s2c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_adc.h instance_piob.h instance_matrix.h instance_ssc.h instance_efc0.h instance_chipid.h instance_usart0.h instance_acc.h instance_rstc.h instance_hsmci.h instance_gpbr.h instance_udp.h instance_twi0.h instance_efc1.h instance_pioc.h instance_rtt.h instance_usart1.h instance_supc.h instance_tc0.h instance_pmc.h instance_uart0.h instance_uart1.h instance_smc.h instance_pioa.h instance_rtc.h instance_tc1.h instance_cmcc.h instance_dacc.h instance_pwm.h instance_spi.h instance_crccu.h instance_wdt.h instance_twi1.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_twi.h component_acc.h component_pio.h component_spi.h component_hsmci.h component_rstc.h component_usart.h component_adc.h component_smc.h component_wdt.h component_udp.h component_pwm.h component_cmcc.h component_matrix.h component_efc.h component_supc.h component_gpbr.h component_ssc.h component_pmc.h component_dacc.h component_rtt.h component_crccu.h component_chipid.h component_rtc.h component_uart.h component_pdc.h component_tc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s4b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4s8b.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4sd32c.h pio_sam4sa16b.h pio_sam4sd16b.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s8c.h pio_sam4s16c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
