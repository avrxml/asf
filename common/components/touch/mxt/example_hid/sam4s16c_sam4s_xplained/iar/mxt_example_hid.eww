<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mxt_example_hid_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mxt_example_hid_sram.ewp</path>
	</project>
</workspace>
