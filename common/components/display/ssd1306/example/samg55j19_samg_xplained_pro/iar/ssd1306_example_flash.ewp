# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ..; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/flexcom; ../../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../../sam/drivers/efc; ../../../../../../../sam/utils/fpu; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/drivers/supc; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../../../../../../sam/utils/cmsis/samg/samg55/include; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/delay; ../../../../../../../sam/utils; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../..; ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/samg
    ../../../../../../services/clock/samg/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/components/display/ssd1306
    ../../../: ssd1306.c font.c font.h ssd1306.h
  group common/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common/components/display/ssd1306/example/samg55j19_samg_xplained_pro
    ../: conf_clock.h conf_board.h conf_ssd1306.h conf_sleepmgr.h conf_spi_master.h
  group common/components/display/ssd1306/example/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/flexcom
    ../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/efc
    ../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../../sam/boards/samg55_xplained_pro/: board_init.c led.h samg55_xplained_pro.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h system_samg55.h samg55n19.h samg55g19.h samg55j18.h samg55j19.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: usart5.h twi0.h usart7.h matrix.h twi2.h i2sc1.h supc.h mem2mem.h flexcom4.h flexcom6.h twi6.h udp.h pioa.h gpbr.h flexcom0.h spi1.h usart4.h spi2.h twi1.h pmc.h flexcom2.h rtt.h twi3.h twi5.h tc1.h flexcom5.h spi6.h twi7.h i2sc0.h flexcom7.h usart2.h spi4.h flexcom1.h spi3.h rtc.h usart3.h efc.h flexcom3.h pdmic1.h adc.h tc0.h cmcc.h spi7.h usart6.h crccu.h spi5.h usart1.h usart0.h rstc.h piob.h wdt.h pdmic0.h twi4.h chipid.h uhp.h spi0.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: matrix.h efc.h chipid.h flexcom.h crccu.h pio.h adc.h i2sc.h supc.h twi.h mem2mem.h uhp.h gpbr.h cmcc.h rtt.h wdt.h tc.h pmc.h spi.h usart.h pdc.h udp.h pdmic.h rtc.h rstc.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55j18.h samg55n19.h samg55g19.h samg55j19.h samg55g18.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
