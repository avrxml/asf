<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ssd1306_example.ewp</path>
	</project>
</workspace>
