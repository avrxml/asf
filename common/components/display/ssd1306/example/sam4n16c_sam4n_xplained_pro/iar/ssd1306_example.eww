<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ssd1306_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ssd1306_example_sram.ewp</path>
	</project>
</workspace>
