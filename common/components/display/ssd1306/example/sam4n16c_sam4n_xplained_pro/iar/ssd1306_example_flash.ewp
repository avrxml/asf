# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4n/include; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils; ../../../../../../../sam/utils/cmsis/sam4n/source/templates; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/boards/sam4n_xplained_pro; ..; ../../../../../../services/delay; ../../..; ../../../../../../utils; ../../../../../../../sam/drivers/pmc; ../../../../../../services/ioport; ../../../../../../../sam/drivers/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/display/ssd1306
    ../../../: ssd1306.c font.c font.h ssd1306.h
  group common/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common/components/display/ssd1306/example/sam4n16c_sam4n_xplained_pro
    ../: conf_clock.h conf_board.h conf_spi_master.h conf_ssd1306.h
  group common/components/display/ssd1306/example/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/sam4n
    ../../../../../../services/clock/sam4n/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../../../sam/boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../../../sam/utils/cmsis/sam4n/source/templates/: exceptions.c system_sam4n.c system_sam4n.h exceptions.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../../../sam/utils/cmsis/sam4n/include/: sam4n8c.h sam4n8a.h sam4n8b.h sam4n16c.h sam4n16b.h sam4n.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../../../sam/utils/cmsis/sam4n/include/instance/: instance_usart1.h instance_spi.h instance_rstc.h instance_tc0.h instance_twi1.h instance_gpbr.h instance_chipid.h instance_adc.h instance_pmc.h instance_supc.h instance_rtt.h instance_wdt.h instance_uart2.h instance_pioa.h instance_matrix.h instance_piob.h instance_usart0.h instance_uart0.h instance_pwm.h instance_dacc.h instance_rtc.h instance_twi2.h instance_pioc.h instance_uart3.h instance_tc1.h instance_twi0.h instance_uart1.h instance_usart2.h instance_efc.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../../../sam/utils/cmsis/sam4n/include/component/: component_tc.h component_wdt.h component_usart.h component_spi.h component_matrix.h component_pdc.h component_rtc.h component_efc.h component_dacc.h component_uart.h component_pwm.h component_twi.h component_rtt.h component_supc.h component_chipid.h component_gpbr.h component_adc.h component_pio.h component_pmc.h component_rstc.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../../../sam/utils/cmsis/sam4n/include/pio/: pio_sam4n16c.h pio_sam4n8a.h pio_sam4n16b.h pio_sam4n8c.h pio_sam4n8b.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
