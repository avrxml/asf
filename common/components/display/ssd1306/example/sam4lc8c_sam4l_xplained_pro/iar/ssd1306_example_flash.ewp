# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC8C__; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../sam/drivers/wdt; ../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../services/delay; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils; ../../../../../../services/clock; ../../../../../../boards; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/drivers/flashcalw; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/sam4l/include; ..; ../../..; ../../../../../../../sam/boards/sam4l8_xplained_pro; ../../../../../../../sam/boards; ../../../../../../../sam/drivers/bpm; ../../../../../../utils; ../../../../../../services/ioport; ../../../../../../../sam/drivers/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4LC8C__; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h osc.h dfll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../services/clock/sam4l/: pll.c sysclk.c osc.c dfll.c dfll.h sysclk.h genclk.h pll.h osc.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_gpio.h
  group common/components/display/ssd1306
    ../../../: ssd1306.c font.c font.h ssd1306.h
  group common/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common/components/display/ssd1306/example/sam4lc8c_sam4l_xplained_pro
    ../: conf_clock.h conf_board.h conf_spi_master.h conf_ssd1306.h
  group common/components/display/ssd1306/example/sam4lc8c_sam4l_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls8a.h sam4ls4a.h sam4lc4b.h sam4ls8c.h sam4lc8a.h sam4lc4c.h sam4l.h sam4lc4a.h sam4lc2b.h sam4ls4b.h sam4ls2a.h sam4ls2c.h sam4lc2c.h sam4lc8b.h sam4lc2a.h sam4lc8c.h sam4ls4c.h sam4ls2b.h sam4ls8b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_pm.h instance_iisc.h instance_chipid.h instance_crccu.h instance_gpio.h instance_wdt.h instance_freqm.h instance_twis1.h instance_dacc.h instance_pdca.h instance_aesa.h instance_twis0.h instance_picouart.h instance_parc.h instance_abdacb.h instance_trng.h instance_bpm.h instance_twim3.h instance_usart1.h instance_usbc.h instance_hmatrix.h instance_usart2.h instance_usart3.h instance_twim1.h instance_scif.h instance_catb.h instance_hcache.h instance_eic.h instance_adcife.h instance_tc1.h instance_pevc.h instance_twim2.h instance_twim0.h instance_gloc.h instance_usart0.h instance_lcdca.h instance_hflashc.h instance_spi.h instance_acifc.h instance_bscif.h instance_ast.h instance_tc0.h instance_smap.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc4c.h pio_sam4ls4c.h pio_sam4lc2b.h pio_sam4lc2a.h pio_sam4lc8c.h pio_sam4ls4a.h pio_sam4lc8b.h pio_sam4ls2a.h pio_sam4lc2c.h pio_sam4ls8a.h pio_sam4ls2b.h pio_sam4lc8a.h pio_sam4ls8c.h pio_sam4lc4b.h pio_sam4ls4b.h pio_sam4ls8b.h pio_sam4ls2c.h pio_sam4lc4a.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_pm.h component_hcache.h component_abdacb.h component_scif.h component_eic.h component_picouart.h component_acifc.h component_aesa.h component_freqm.h component_twis.h component_twim.h component_trng.h component_gloc.h component_chipid.h component_pdca.h component_smap.h component_tc.h component_ast.h component_wdt.h component_flashcalw.h component_gpio.h component_iisc.h component_crccu.h component_dacc.h component_parc.h component_bpm.h component_spi.h component_lcdca.h component_usbc.h component_adcife.h component_usart.h component_pevc.h component_catb.h component_hmatrixb.h component_bscif.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h stringz.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../../../sam/boards/sam4l8_xplained_pro/: init.c sam4l8_xplained_pro.h led.h
