<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hx8347a_example.ewp</path>
	</project>
</workspace>
