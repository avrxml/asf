<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hx8347a_example2.ewp</path>
	</project>
</workspace>
