<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\st7565r_example.ewp</path>
	</project>
</workspace>
