<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ili9341_example1.ewp</path>
	</project>
</workspace>
