# IAR project ili9341_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../services/delay; ../../..; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../services/gpio; ..; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/utils; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../../../../xmega/drivers/nvm; ../../../../../../utils; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/spi; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../../../xmega/utils/: status_codes.h compiler.h assembler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group common/components/display/ili9341
    ../../../: ili9341.c ili9341.h ili9341_regs.h
  group common/components/display/ili9341/example1_basic
    ../../: ili9341_example.c
  group common/components/display/ili9341/example1_basic/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_usart_spi.h conf_ili9341.h conf_clock.h conf_board.h
  group common/components/display/ili9341/example1_basic/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../boards/: board.h
