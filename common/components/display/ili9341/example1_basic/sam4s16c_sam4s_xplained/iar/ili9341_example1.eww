<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ili9341_example1_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ili9341_example1_sram.ewp</path>
	</project>
</workspace>
