# IAR project nvm_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../sam/utils; ..; ../../../../../services/clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/boards/sam3u_ek; ../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../services/ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/services/flash_efc; ../../..; ../../../../../../sam/drivers/pio; ../../../../../utils; ../../../../../services/gpio; ../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nvm_example_flash.bin
  ILINK.IlinkOutputFile: nvm_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/drivers/nvm
    ../../../: common_nvm.h
  group common/drivers/nvm/sam
    ../../../sam/: sam_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/drivers/nvm/example/sam3u4e_sam3u_ek
    ../: conf_clock.h conf_board.h conf_nvm_example.h conf_nvm.h
  group common/drivers/nvm/example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam3u
    ../../../../../services/clock/sam3u/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/gpio
    ../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../boards/: board.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../sam/utils/cmsis/sam3u/include/: sam3u2c.h sam3u1e.h sam3u4e.h sam3u4c.h sam3u2e.h sam3u.h sam3u1c.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_usart2.h instance_usart0.h instance_piob.h instance_twi0.h instance_tc0.h instance_chipid.h instance_spi.h instance_supc.h instance_smc.h instance_efc1.h instance_usart3.h instance_pwm.h instance_rtt.h instance_usart1.h instance_dmac.h instance_wdt.h instance_efc0.h instance_gpbr.h instance_ssc.h instance_adc.h instance_matrix.h instance_hsmci.h instance_uart.h instance_rstc.h instance_udphs.h instance_pioc.h instance_twi1.h instance_pioa.h instance_rtc.h instance_pmc.h instance_adc12b.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../sam/utils/cmsis/sam3u/include/component/: component_matrix.h component_ssc.h component_usart.h component_pwm.h component_wdt.h component_spi.h component_adc.h component_efc.h component_pio.h component_smc.h component_dmac.h component_rtt.h component_udphs.h component_pmc.h component_hsmci.h component_supc.h component_rtc.h component_twi.h component_tc.h component_pdc.h component_gpbr.h component_rstc.h component_chipid.h component_uart.h component_adc12b.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2c.h pio_sam3u2e.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u4c.h pio_sam3u4e.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3u_ek
    ../../../../../../sam/boards/sam3u_ek/: led.c init.c led.h sam3u_ek.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
