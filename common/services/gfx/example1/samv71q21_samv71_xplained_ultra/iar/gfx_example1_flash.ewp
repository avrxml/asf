# IAR project gfx_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ILI9488_EBIMODE; __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true; CONF_GFX_ILI9488=1
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/samv71/source/templates; ../../../../../../sam/drivers/ebi/smc; ../../..; ../../../../../../sam/utils; ../../../../../../sam/utils/fpu; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ..; ../../../../clock; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/boards/samv71_xplained_ultra; ../../../../../../sam/drivers/mpu; ../../../../../../sam/drivers/pio; ../../../../../utils; ../../../../../../sam/components/display/ili9488; ../../../../gpio; ../../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gfx_example1_flash.bin
  ILINK.IlinkOutputFile: gfx_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/ebi/smc
    ../../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../sam/boards/samv71_xplained_ultra/: init.c samv71_xplained_ultra.h led.h
  group sam/components/display/ili9488
    ../../../../../../sam/components/display/ili9488/: ili9488.c ili9488.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../sam/utils/cmsis/samv71/include/: samv71n20.h samv71q20b.h samv71j21b.h samv71j21.h samv71.h samv71n21.h samv71n19b.h samv71q19.h samv71j20b.h samv71q21.h samv71q21b.h samv71q19b.h samv71n20b.h samv71j19b.h samv71j20.h samv71n21b.h samv71q20.h samv71j19.h samv71n19.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../sam/utils/cmsis/samv71/include/component/: tc.h hsmci.h uart.h rtt.h acc.h aes.h rstc.h qspi.h usart.h pio.h supc.h rswdt.h matrix.h sdramc.h wdt.h spi.h twihs.h pwm.h icm.h usbhs.h gpbr.h pmc.h isi.h afec.h trng.h i2sc.h utmi.h dacc.h ssc.h efc.h rtc.h smc.h chipid.h mlb.h mcan.h xdmac.h gmac.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../sam/utils/cmsis/samv71/include/instance/: mcan1.h i2sc0.h usart2.h uart0.h gmac.h tc1.h uart2.h tc3.h rswdt.h supc.h icm.h isi.h pwm0.h pioe.h pwm1.h chipid.h trng.h afec0.h efc.h usart0.h afec1.h pioa.h smc.h piod.h spi1.h ssc.h dacc.h mlb.h twihs2.h pmc.h wdt.h aes.h pioc.h twihs0.h acc.h hsmci.h usart1.h piob.h utmi.h xdmac.h sdramc.h mcan0.h spi0.h matrix.h usbhs.h twihs1.h rtc.h uart4.h rtt.h uart1.h tc0.h rstc.h qspi.h tc2.h uart3.h i2sc1.h gpbr.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71n21b.h samv71n19.h samv71n19b.h samv71n20b.h samv71j21b.h samv71n20.h samv71q20.h samv71n21.h samv71q19b.h samv71j19b.h samv71j19.h samv71q21.h samv71q20b.h samv71q21b.h samv71j20.h samv71j20b.h samv71j21.h samv71q19.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group common/services/gfx
    ../../../: gfx_text.c gfx_generic.c gfx_ili9488_90_00028_a0.c sysfont.c sysfont.h gfx_ili9488_90_00028_a0.h gfx_generic.h gfx_text.h gfx.h
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/gfx/example1/samv71q21_samv71_xplained_ultra
    ../: conf_ili9488.h conf_clock.h conf_board.h atmel_logo.h conf_sysfont.h smiley.h
  group common/services/gfx/example1/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/samv71
    ../../../../clock/samv71/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
