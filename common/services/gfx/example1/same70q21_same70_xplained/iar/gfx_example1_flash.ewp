# IAR project gfx_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ILI9488_SPIMODE; ARM_MATH_CM7=true; CONF_GFX_ILI9488=1
  ICCARM.CCIncludePath2: ../../../../spi/sam_spi; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/same70/include; ../../..; ..; ../../../../../../sam/utils/fpu; ../../../../../../sam/drivers/spi; ../../../../../../sam/drivers/mpu; ../../../../../utils; ../../../../../../sam/components/display/ili9488; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/boards/same70_xplained; ../../../../gpio; ../../../../../../sam/utils; ../../../../spi; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../ioport; ../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gfx_example1_flash.bin
  ILINK.IlinkOutputFile: gfx_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70n21b.h same70.h same70q20.h same70n21.h same70j19.h same70n20b.h same70n20.h same70q21b.h same70q20b.h same70j20b.h same70j20.h same70q19b.h same70j21b.h same70j19b.h same70j21.h same70q19.h same70n19.h same70n19b.h same70q21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: pmc.h smc.h i2sc0.h mcan1.h matrix.h uart3.h piod.h uart1.h i2sc1.h usart1.h qspi.h tc1.h rswdt.h pioe.h acc.h piob.h hsmci.h usart2.h xdmac.h uart0.h twihs1.h tc3.h uart2.h twihs0.h sdramc.h spi1.h usbhs.h efc.h ssc.h rtc.h chipid.h afec0.h trng.h twihs2.h gmac.h wdt.h isi.h spi0.h icm.h rstc.h utmi.h dacc.h afec1.h rtt.h mcan0.h supc.h gpbr.h pwm1.h uart4.h usart0.h tc2.h pwm0.h pioa.h tc0.h aes.h pioc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70j20.h same70j19.h same70q21.h same70j19b.h same70q19b.h same70n21b.h same70n20.h same70q21b.h same70j21.h same70q20.h same70j20b.h same70n19.h same70n19b.h same70q19.h same70n20b.h same70j21b.h same70q20b.h same70n21.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: afec.h spi.h pio.h acc.h qspi.h hsmci.h usbhs.h chipid.h rstc.h gmac.h wdt.h smc.h rswdt.h pwm.h matrix.h utmi.h usart.h xdmac.h aes.h efc.h gpbr.h mcan.h supc.h pmc.h rtt.h i2sc.h dacc.h isi.h twihs.h rtc.h sdramc.h ssc.h icm.h trng.h uart.h tc.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group sam/components/display/ili9488
    ../../../../../../sam/components/display/ili9488/: ili9488.c ili9488.h
  group common/services/gfx
    ../../../: gfx_text.c gfx_ili9488_90_00028_a0.c sysfont.c gfx_generic.c gfx_ili9488_90_00028_a0.h gfx_generic.h gfx.h gfx_text.h sysfont.h
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/gfx/example1/same70q21_same70_xplained
    ../: conf_ili9488.h conf_board.h atmel_logo.h conf_sysfont.h conf_spi_master.h conf_clock.h smiley.h
  group common/services/gfx/example1/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/same70
    ../../../../clock/same70/: sysclk.c sysclk.h pll.h osc.h genclk.h
  group common/services/spi
    ../../../../spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../spi/sam_spi/: spi_master.c spi_master.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
