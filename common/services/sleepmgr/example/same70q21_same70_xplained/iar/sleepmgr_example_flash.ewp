# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../delay; ../../../../../../sam/drivers/rtt; ../../../../../../sam/utils; ../../../../../../sam/boards/same70_xplained; ../../../../../../sam/utils/fpu; ../../../../../../sam/utils/cmsis/same70/include; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../clock; ../../../../../../sam/utils/cmsis/same70/source/templates; ..; ../../../../../../sam/drivers/pio; ../../../../../../sam/drivers/mpu; ../../../../../../sam/drivers/supc; ../../..; ../../../../../utils; ../../../../gpio; ../../../../../../sam/drivers/pmc; ../../../../ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/rtt
    ../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70n21b.h same70.h same70q20.h same70n21.h same70j19.h same70n20b.h same70n20.h same70q21b.h same70q20b.h same70j20b.h same70j20.h same70q19b.h same70j21b.h same70j19b.h same70j21.h same70q19.h same70n19.h same70n19b.h same70q21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: pmc.h smc.h i2sc0.h mcan1.h matrix.h uart3.h piod.h uart1.h i2sc1.h usart1.h qspi.h tc1.h rswdt.h pioe.h acc.h piob.h xdmac.h uart0.h tc3.h uart2.h twihs0.h sdramc.h spi1.h usbhs.h efc.h ssc.h rtc.h chipid.h hsmci.h afec0.h trng.h twihs2.h gmac.h wdt.h spi0.h usart2.h icm.h rstc.h utmi.h dacc.h afec1.h aes.h rtt.h mcan0.h gpbr.h supc.h pwm1.h uart4.h usart0.h tc2.h isi.h pwm0.h pioa.h tc0.h twihs1.h pioc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70j20.h same70j19.h same70q21.h same70j19b.h same70q19b.h same70n21b.h same70n20.h same70q21b.h same70q20b.h same70q20.h same70j20b.h same70n19.h same70n19b.h same70q19.h same70j21.h same70n20b.h same70j21b.h same70n21.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: afec.h spi.h pio.h acc.h qspi.h hsmci.h usbhs.h chipid.h aes.h isi.h icm.h rstc.h gmac.h wdt.h smc.h rswdt.h pwm.h matrix.h utmi.h usart.h xdmac.h efc.h mcan.h supc.h pmc.h rtt.h i2sc.h dacc.h gpbr.h twihs.h rtc.h sdramc.h ssc.h trng.h uart.h tc.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/same70
    ../../../../clock/same70/: sysclk.c sysclk.h pll.h osc.h genclk.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../sam/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam_rtt.c
  group common/services/sleepmgr/example/same70q21_same70_xplained
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/sleepmgr/example/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../boards/: board.h
