# IAR project spi_master_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../delay; ../../../../../../sam/drivers/usart; ../../../sam_spi; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../..; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/flashcalw; ../../../../../../sam/utils/preprocessor; ../../../../../boards; ../../../../../../sam/boards/sam4l_ek; ../../../../ioport; ../../../../../../sam/drivers/spi; ../../../../../../sam/drivers/bpm; ../../../../../utils; ..; ../../../../../../sam/utils/cmsis/sam4l/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_master_example_flash.bin
  ILINK.IlinkOutputFile: spi_master_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../sam/utils/cmsis/sam4l/include/: sam4l_patch_asf.h sam4l.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/bpm
    ../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/flashcalw
    ../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/boards/sam4l_ek
    ../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c led.h sam4l_ek.h board_monitor.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h dfll.h osc.h sysclk.h
  group common/services/clock/sam4l
    ../../../../clock/sam4l/: sysclk.c dfll.c pll.c osc.c dfll.h genclk.h pll.h osc.h sysclk.h
  group common/services/spi
    ../../../: spi_master.h
  group common/services/spi/master_example
    ../../: spi_master_example_sam.c
  group common/services/spi/master_example/sam4lc4c_sam4l_ek
    ../: conf_clock.h conf_spi_master_example.h conf_board.h conf_spi_master.h
  group common/services/spi/master_example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/spi/sam_spi
    ../../../sam_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
