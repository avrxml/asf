# IAR project basic_usart_spi_master_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../sam/utils; ..; ../../../../clock; ../../../../../../sam/boards; ../../..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/boards/sam3u_ek; ../../../../../../sam/utils/cmsis/sam3u/include; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../utils; ../../../../gpio; ../../../../../../sam/drivers/usart; ../../../sam_usart_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: basic_usart_spi_master_example_flash.bin
  ILINK.IlinkOutputFile: basic_usart_spi_master_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../sam/utils/cmsis/sam3u/include/: sam3u2c.h sam3u1e.h sam3u4e.h sam3u4c.h sam3u2e.h sam3u.h sam3u1c.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_usart2.h instance_usart0.h instance_piob.h instance_twi0.h instance_tc0.h instance_chipid.h instance_spi.h instance_supc.h instance_smc.h instance_efc1.h instance_usart3.h instance_pwm.h instance_rtt.h instance_usart1.h instance_dmac.h instance_wdt.h instance_efc0.h instance_gpbr.h instance_ssc.h instance_adc.h instance_matrix.h instance_hsmci.h instance_uart.h instance_rstc.h instance_udphs.h instance_pioc.h instance_twi1.h instance_pioa.h instance_rtc.h instance_pmc.h instance_adc12b.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../sam/utils/cmsis/sam3u/include/component/: component_matrix.h component_ssc.h component_pwm.h component_wdt.h component_spi.h component_adc.h component_efc.h component_pio.h component_smc.h component_dmac.h component_rtt.h component_udphs.h component_usart.h component_pmc.h component_gpbr.h component_hsmci.h component_adc12b.h component_supc.h component_rtc.h component_twi.h component_tc.h component_pdc.h component_rstc.h component_chipid.h component_uart.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2c.h pio_sam3u2e.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u4c.h pio_sam3u4e.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3u_ek
    ../../../../../../sam/boards/sam3u_ek/: led.c init.c led.h sam3u_ek.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3u
    ../../../../clock/sam3u/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/spi
    ../../../: usart_spi.h
  group common/services/spi/sam_usart_spi
    ../../../sam_usart_spi/: usart_spi.c usart_spi.h
  group common/services/spi/usart_spi_master_example
    ../../: usart_spi_master_example.c
  group common/services/spi/usart_spi_master_example/sam3u4e_sam3u_ek
    ../: conf_usart_spi.h conf_clock.h conf_usart_spi_master_example.h conf_board.h
  group common/services/spi/usart_spi_master_example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
