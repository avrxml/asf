# IAR project example_sysfont.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: GFX_MONO_UG_2832HSWEG04=1; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../delay; ..; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../../../spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../..; ../../../../../../xmega/boards/xmega_c3_xplained; ../../../../ioport; ../../../../../../xmega/drivers/usart; ../../../../../components/display/ssd1306; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../..; ../../../../gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; GFX_MONO_UG_2832HSWEG04=1; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/gfx_mono
    ../../../: sysfont.c gfx_mono_framebuffer.c gfx_mono_generic.c gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_text.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_generic.h gfx_mono.h sysfont.h
  group common/services/gfx_mono/example_sysfont
    ../../: example_sysfont.c
  group common/services/gfx_mono/example_sysfont/atxmega384c3_xmega_c3_xplained
    ../: conf_usart_spi.h conf_ssd1306.h conf_clock.h conf_board.h conf_sysfont.h
  group common/services/gfx_mono/example_sysfont/atxmega384c3_xmega_c3_xplained/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/spi
    ../../../../spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/xmega
    ../../../../delay/xmega/: cycle_counter.h
  group common/components/display/ssd1306
    ../../../../../components/display/ssd1306/: ssd1306.c font.c ssd1306.h font.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_c3_xplained
    ../../../../../../xmega/boards/xmega_c3_xplained/: init.c led.h xmega_c3_xplained.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
