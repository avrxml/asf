<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tests_targets.ewp</path>
	</project>
</workspace>
