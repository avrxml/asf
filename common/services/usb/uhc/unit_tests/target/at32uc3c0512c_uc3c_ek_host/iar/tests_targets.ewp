# IAR project tests_targets.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; UHD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../class/hid/host/mouse; ../../../../../../../../avr32/drivers/scif; ../../../../../../../boards; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/drivers/usbc; ../../../../../../../../avr32/drivers/pm; ../../../../../../../../avr32/boards/uc3c_ek; ../../../../../../serial; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/gpio; ../../../../../../sleepmgr; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../utils/stdio/stdio_serial; ../..; ../../../../..; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../delay; ../../../../../../serial/uc3_usart; ..; ../../../../../../../../avr32/drivers/usart; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/utils/preprocessor; ../../../../../class/hid; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../serial/uc3_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h sysclk.h pll.h
  group common/services/clock/uc3c
    ../../../../../../clock/uc3c/: osc.c sysclk.c pll.c osc.h genclk.h sysclk.h pll.h
  group common/services/usb
    ../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/uhc
    ../../../../: uhc.c uhd.h uhi.h uhc.h
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c unit_tests.h conf_usb_host.h
  group common/services/usb/uhc/unit_tests/target/at32uc3c0512c_uc3c_ek_host
    ../: conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group common/services/usb/uhc/unit_tests/target/at32uc3c0512c_uc3c_ek_host/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/delay
    ../../../../../../delay/: delay.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../boards/: board.h
  group avr32/drivers/usart
    ../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pm
    ../../../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c pm_uc3c.h power_clocks_lib.h sleep.h
  group avr32/drivers/usbc
    ../../../../../../../../avr32/drivers/usbc/: usbc_host.c usbc_otg.h usbc_host.h
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/scif
    ../../../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3c_ek
    ../../../../../../../../avr32/boards/uc3c_ek/: led.c init.c uc3c_ek.h led.h
  group avr32/utils
    ../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../avr32/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
