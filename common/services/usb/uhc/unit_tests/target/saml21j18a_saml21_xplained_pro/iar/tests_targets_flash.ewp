# IAR project tests_targets_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; _ASSERT_ENABLE_; EXTINT_CALLBACK_MODE=true; __SAML21J18A__; UHD_ENABLE; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; USB_HOST_LPM_SUPPORT; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..; ../../../../../../../../sam0/drivers/system/power; ../../../../../class/hid/host/mouse; ../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sam0/boards/saml21_xplained_pro; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../common2/services/delay; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/port; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../serial; ../../../../../../sleepmgr; ../../../../../../../utils; ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../..; ../..; ../../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../..; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../common2/services/delay/sam0; ../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../sam0/utils/cmsis/saml21/include; ../../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../boards; ../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/drivers/usb; ../../../../../../../../sam0/drivers/system; ../../../../../../../../sam0/drivers/extint; ../../../../../class/hid; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tests_targets_flash.bin
  ILINK.IlinkOutputFile: tests_targets_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/usb
    ../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/extint
    ../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../../sam0/utils/cmsis/saml21/include/: saml21g18a.h saml21j18a.h saml21.h saml21e18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../../sam0/utils/cmsis/saml21/include/component/: osc32kctrl.h dmac.h aes.h ccl.h dsu.h dac.h mclk_100.h port.h tal.h pm_100.h wdt.h rtc_100.h rstc_100.h eic_100.h pac_100.h sercom.h evsys.h tc_100.h usb.h tcc_200.h adc_100.h supc_100.h mtb.h trng.h ac.h gclk_100.h oscctrl.h opamp.h nvmctrl_301.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../../sam0/utils/cmsis/saml21/include/instance/: tc4_100.h aes.h tcc2_200.h rtc_100.h eic_100.h mtb.h tc1_100.h tcc0_200.h oscctrl.h tc3_100.h tc2_100.h opamp.h evsys.h sercom1.h dmac.h supc_100.h nvmctrl_301.h wdt.h tal.h dsu.h gclk_100.h osc32kctrl.h usb.h sercom5.h port.h sercom0.h sercom3.h mclk_100.h pm_100.h trng.h sercom4.h sercom2.h tcc1_200.h dac.h ccl.h tc0_100.h pac_100.h rstc_100.h ac.h adc_100.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group common/services/usb
    ../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/uhc
    ../../../../: uhc.c uhc.h uhi.h uhd.h
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c conf_usb_host.h unit_tests.h
  group common/services/usb/uhc/unit_tests/target/saml21j18a_saml21_xplained_pro
    ../: conf_board.h conf_sleepmgr.h conf_test.h conf_clocks.h conf_extint.h
  group common/services/usb/uhc/unit_tests/target/saml21j18a_saml21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/sleepmgr
    ../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../../boards/: board.h
  group common2/services/delay
    ../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
