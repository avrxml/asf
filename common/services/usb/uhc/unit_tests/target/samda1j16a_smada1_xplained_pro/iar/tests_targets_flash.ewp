# IAR project tests_targets_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; _ASSERT_ENABLE_; EXTINT_CALLBACK_MODE=true; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO; UHD_ENABLE; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; USB_HOST_LPM_SUPPORT
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/drivers/port; ../../../../../class/hid/host/mouse; ../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../common2/services/delay; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/system/power; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../sam0/utils/cmsis/samda1/include; ../../../../../../serial; ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../sleepmgr; ../../../../../../../utils; ../../../../../../../../sam0/drivers/system/interrupt; ../../../..; ..; ../../../../../../../../sam0/boards/samda1_xplained_pro; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda; ../../../../..; ../..; ../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../common2/services/delay/sam0; ../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../sam0/utils/cmsis/samda1/source; ../../../../../../../boards; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/drivers/usb; ../../../../../../../../sam0/drivers/system; ../../../../../../../../sam0/drivers/extint; ../../../../../class/hid; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tests_targets_flash.bin
  ILINK.IlinkOutputFile: tests_targets_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/usb
    ../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/drivers/extint
    ../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../../../sam0/utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../../../sam0/utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../../../sam0/utils/cmsis/samda1/include/: samda1g16a.h samda1e14a.h samda1.h samda1g15a.h samda1j14b.h samda1j15a.h samda1j16a.h samda1g14b.h samda1e15b.h samda1e14b.h samda1g14a.h samda1j16b.h samda1e16b.h samda1j15b.h samda1j14a.h samda1e15a.h samda1g16b.h samda1e16a.h samda1g15b.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../../../sam0/utils/cmsis/samda1/include/instance/: tcc2.h tc6.h evsys.h tcc0.h port.h gclk.h dsu.h pac0.h pac2.h sercom2.h sysctrl.h sercom4.h mtb.h tc4.h usb.h pm.h sercom0.h sercom3.h dmac.h adc.h sercom5.h eic.h sbmatrix.h nvmctrl.h tc7.h rtc.h dac.h tcc1.h tc5.h tc3.h wdt.h ac.h sercom1.h i2s.h pac1.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../../../sam0/utils/cmsis/samda1/include/component/: pac.h wdt.h nvmctrl.h i2s.h dmac.h sercom.h mtb.h hmatrixb.h tcc.h dac.h pm.h evsys.h ac.h rtc.h gclk.h adc.h eic.h port.h dsu.h sysctrl.h tc.h usb.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../../../sam0/utils/cmsis/samda1/include/pio/: samda1e14b.h samda1e14a.h samda1g14b.h samda1g14a.h samda1j16b.h samda1g15b.h samda1g16b.h samda1e15b.h samda1e16a.h samda1j16a.h samda1g15a.h samda1j15a.h samda1j14b.h samda1e16b.h samda1g16a.h samda1e15a.h samda1j14a.h samda1j15b.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: stringz.h preprocessor.h mrecursion.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../../../../sam0/boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/services/usb
    ../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/uhc
    ../../../../: uhc.c uhi.h uhd.h uhc.h
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c unit_tests.h conf_usb_host.h
  group common/services/usb/uhc/unit_tests/target/samda1j16a_smada1_xplained_pro
    ../: conf_test.h conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/uhc/unit_tests/target/samda1j16a_smada1_xplained_pro/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/sleepmgr
    ../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../../boards/: board.h
  group common2/services/delay
    ../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
