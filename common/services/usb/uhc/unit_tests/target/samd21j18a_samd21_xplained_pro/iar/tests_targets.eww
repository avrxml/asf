<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tests_targets_flash.ewp</path>
	</project>
</workspace>
