<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tests_targets_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\tests_targets_sram.ewp</path>
	</project>
</workspace>
