<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tests_generator_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\tests_generator_sram.ewp</path>
	</project>
</workspace>
