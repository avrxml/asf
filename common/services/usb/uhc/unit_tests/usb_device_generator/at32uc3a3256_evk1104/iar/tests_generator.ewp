# IAR project tests_generator.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../delay; ../../../../../../../../avr32/utils/preprocessor; ../../../../../../clock; ..; ../../../../../class/hid; ../../../../../../../boards; ../../../../..; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/boards/evk1104; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../../avr32/drivers/gpio; ../../../../../../../../avr32/drivers/usbb; ../../../../../../../utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbb
    ../../../../../../../../avr32/drivers/usbb/: usbb_device.h usbb_host.h usbb_otg.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1104
    ../../../../../../../../avr32/boards/evk1104/: led.c init.c evk1104.h led.h
  group avr32/utils
    ../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../avr32/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group common/services/usb
    ../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/uhc/unit_tests/usb_device_generator
    ../../: unit_tests.c unit_tests.h
  group common/services/usb/uhc/unit_tests/usb_device_generator/at32uc3a3256_evk1104
    ../: conf_clock.h conf_board.h
  group common/services/usb/uhc/unit_tests/usb_device_generator/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../class/hid/: usb_protocol_hid.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h sysclk.h pll.h
  group common/services/clock/uc3a3_a4
    ../../../../../../clock/uc3a3_a4/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/delay
    ../../../../../../delay/: delay.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../boards/: board.h
