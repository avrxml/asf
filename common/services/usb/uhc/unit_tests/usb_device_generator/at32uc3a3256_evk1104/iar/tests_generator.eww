<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tests_generator.ewp</path>
	</project>
</workspace>
