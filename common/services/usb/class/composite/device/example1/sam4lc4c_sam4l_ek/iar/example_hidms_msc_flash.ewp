# IAR project example_hidms_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; ACCESS_USB_ENABLED; UDD_ENABLE; VIRTUAL_MEMORY_ENABLE; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../sam/utils/preprocessor; ../../../../../msc; ../..; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam/drivers/eic; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../../../sam/boards/sam4l_ek; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/gpio; ../../../../../../../delay; ../../../../../../../../../sam/utils; ../../../../../hid/device; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../hid; ../../../../../../../../../sam/drivers/bpm; ..; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hidms_msc_flash.bin
  ILINK.IlinkOutputFile: example_hidms_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h dfll.h pll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../clock/sam4l/: pll.c dfll.c sysclk.c osc.c pll.h dfll.h sysclk.h genclk.h osc.h
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse.h
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/composite/device/example1
    ../../: memories_initialization_sam.c main.c conf_usb.h main.h ui.h
  group common/services/usb/class/composite/device/example1/sam4lc4c_sam4l_ek
    ../: ui.c conf_sleepmgr.h conf_virtual_mem.h conf_clock.h conf_board.h conf_access.h
  group common/services/usb/class/composite/device/example1/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h sbc_protocol.h spc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc.h udc_desc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/boards/sam4l_ek
    ../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c board_monitor.h led.h sam4l_ek.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/gpio
    ../../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/usbc
    ../../../../../../../../../sam/drivers/usbc/: usbc_device.c usbc_otg.h usbc_device.h
  group sam/drivers/eic
    ../../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/utils
    ../../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
