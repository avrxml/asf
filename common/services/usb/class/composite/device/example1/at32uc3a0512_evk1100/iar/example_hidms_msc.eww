<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_hidms_msc.ewp</path>
	</project>
</workspace>
