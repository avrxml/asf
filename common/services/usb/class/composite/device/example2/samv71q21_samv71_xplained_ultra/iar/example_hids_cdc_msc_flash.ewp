# IAR project example_hids_cdc_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ACCESS_USB_ENABLED; UDD_ENABLE; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true; VIRTUAL_MEMORY_ENABLE; __SAMV71Q21B__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/utils/cmsis/samv71/source/templates; ../../../../../cdc/device; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../msc; ../..; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam/utils/fpu; ..; ../../../../../hid/device/kbd; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../cdc; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../../../sam/boards/samv71_xplained_ultra; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/mpu; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/usbhs; ../../../../../../../gpio; ../../../../../../../../../sam/utils; ../../../../../hid/device; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/utils/cmsis/samv71/include; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hids_cdc_msc_flash.bin
  ILINK.IlinkOutputFile: example_hids_cdc_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/mpu
    ../../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/usbhs
    ../../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../../../../sam/utils/cmsis/samv71/include/: samv71q20b.h samv71n19b.h samv71j21.h samv71q19.h samv71j19b.h samv71j20.h samv71q21.h samv71q21b.h samv71n20.h samv71j19.h samv71n21.h samv71j20b.h samv71n19.h samv71j21b.h samv71n20b.h samv71q20.h samv71.h samv71q19b.h samv71n21b.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71j20.h samv71q19.h samv71n19.h samv71j19.h samv71j21b.h samv71j21.h samv71q19b.h samv71j19b.h samv71j20b.h samv71n21b.h samv71q21.h samv71n20b.h samv71q21b.h samv71n20.h samv71q20b.h samv71q20.h samv71n21.h samv71n19b.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../../../../sam/utils/cmsis/samv71/include/instance/: gpbr.h pwm1.h chipid.h hsmci.h piod.h tc2.h matrix.h tc1.h icm.h pmc.h tc3.h rstc.h rswdt.h uart0.h efc.h piob.h rtc.h smc.h mlb.h pioe.h twihs2.h afec1.h tc0.h spi0.h usart1.h i2sc1.h rtt.h sdramc.h mcan1.h uart4.h twihs1.h acc.h pioa.h uart2.h pioc.h uart3.h uart1.h utmi.h dacc.h wdt.h spi1.h usart0.h i2sc0.h afec0.h isi.h supc.h pwm0.h mcan0.h gmac.h twihs0.h usart2.h qspi.h usbhs.h xdmac.h trng.h aes.h ssc.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../../../../sam/utils/cmsis/samv71/include/component/: rtc.h sdramc.h gpbr.h i2sc.h trng.h ssc.h mcan.h acc.h qspi.h pmc.h aes.h afec.h spi.h chipid.h gmac.h utmi.h rswdt.h rstc.h efc.h pwm.h usbhs.h smc.h hsmci.h isi.h twihs.h icm.h matrix.h usart.h rtt.h pio.h tc.h uart.h wdt.h dacc.h supc.h xdmac.h mlb.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/fpu
    ../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../../../../sam/boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse.h
  group common/services/usb/class/hid/device/kbd
    ../../../../../hid/device/kbd/: udi_hid_kbd.c udi_hid_kbd.h
  group common/services/usb/class/cdc
    ../../../../../cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../cdc/device/: udi_cdc.c udi_cdc.h
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/composite/device/example2
    ../../: uart_sam.c memories_initialization_sam.c main.c uart.h conf_usb.h main.h ui.h
  group common/services/usb/class/composite/device/example2/samv71q21_samv71_xplained_ultra
    ../: ui.c conf_virtual_mem.h conf_example.h conf_clock.h conf_board.h conf_sleepmgr.h conf_access.h
  group common/services/usb/class/composite/device/example2/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc.h udd.h udc_desc.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/samv71
    ../../../../../../../clock/samv71/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
