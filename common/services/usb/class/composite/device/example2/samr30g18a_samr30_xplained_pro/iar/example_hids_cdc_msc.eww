<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_hids_cdc_msc_flash.ewp</path>
	</project>
</workspace>
