<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_cdc_msc.ewp</path>
	</project>
</workspace>
