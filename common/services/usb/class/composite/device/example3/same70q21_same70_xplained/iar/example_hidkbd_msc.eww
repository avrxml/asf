<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_hidkbd_msc_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\example_hidkbd_msc_sram.ewp</path>
	</project>
</workspace>
