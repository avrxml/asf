<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_hidkbd_msc.ewp</path>
	</project>
</workspace>
