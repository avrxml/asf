# IAR project host_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD21_XPLAINED_PRO; RTC_CALENDAR_ASYNC=false; EXTINT_CALLBACK_MODE=true; UHD_ENABLE; USB_HOST_LPM_SUPPORT; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21; ../../../../../../../../../sam0/drivers/port; ../../../../../hid/host/mouse; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../msc; ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/usb; ../..; ../../../../../../../../../sam0/drivers/rtc; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../uhc; ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../../msc/host; ../../../../../..; ..; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../hid; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../storage/ctrl_access; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example2_flash.bin
  ILINK.IlinkOutputFile: host_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/usb/class/composite/host/example2
    ../../: main.c conf_fatfs.h conf_access.h conf_usb_host.h main.h ui.h
  group common/services/usb/class/composite/host/example2/samd21j18a_samd21_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/composite/host/example2/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/rtc
    ../../../../../../../../../sam0/drivers/rtc/: rtc_calendar.c rtc_calendar.h
  group sam0/drivers/rtc/quick_start_calendar
    ../../../../../../../../../sam0/drivers/rtc/quick_start_calendar/: qs_rtc_calendar_basic.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.c usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.c extint_callback.h extint.h
  group sam0/drivers/extint/quick_start_callback
    ../../../../../../../../../sam0/drivers/extint/quick_start_callback/: qs_extint_callback.h
  group sam0/drivers/extint/quick_start_polled
    ../../../../../../../../../sam0/drivers/extint/quick_start_polled/: qs_extint_basic.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21j16a.h samd21g16a.h samd21.h samd21g18a.h samd21g17a.h samd21e17a.h samd21e16a.h samd21j15a.h samd21g15a.h samd21e18a.h samd21j18a.h samd21j17a.h samd21e15a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: port.h dmac.h evsys.h i2s.h tcc.h mtb.h pm.h tc.h wdt.h gclk.h pac.h rtc.h sysctrl.h usb.h dac.h dsu.h eic.h sercom.h ac.h nvmctrl.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac.h sercom1.h dac.h sercom3.h pac0.h pac2.h tc7.h mtb.h adc.h tc5.h eic.h tcc2.h tc3.h tcc0.h tcc1.h dsu.h i2s.h sercom4.h nvmctrl.h gclk.h usb.h wdt.h sercom0.h port.h pac1.h sercom2.h tc6.h evsys.h sysctrl.h dmac.h sercom5.h tc4.h pm.h rtc.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21e15a.h samd21g15a.h samd21e17a.h samd21j17a.h samd21g16a.h samd21j16a.h samd21g18a.h samd21e18a.h samd21g17a.h samd21e16a.h samd21j18a.h samd21j15a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ffconf.h integer.h ff.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
