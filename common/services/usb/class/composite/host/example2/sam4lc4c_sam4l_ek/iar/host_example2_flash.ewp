# IAR project host_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../hid/host/mouse; ../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../sam/utils/preprocessor; ..; ../../../../../msc; ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../..; ../../../../../../../../../sam/drivers/ast; ../../../../../../../../../sam/drivers/eic; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam/boards/sam4l_ek; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../..; ../../../../../../../../../sam/drivers/gpio; ../../../../../msc/host; ../../../../../../../delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../hid; ../../../../../../../../../sam/drivers/bpm; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: UHD_ENABLE; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example2_flash.bin
  ILINK.IlinkOutputFile: host_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h sbc_protocol.h spc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/usb/class/composite/host/example2
    ../../: main.c conf_access.h conf_fatfs.h ui.h main.h conf_usb_host.h
  group common/services/usb/class/composite/host/example2/sam4lc4c_sam4l_ek
    ../: ui.c conf_ast.h conf_clock.h conf_sleepmgr.h conf_board.h
  group common/services/usb/class/composite/host/example2/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h sysclk.h dfll.h pll.h
  group common/services/clock/sam4l
    ../../../../../../../clock/sam4l/: pll.c dfll.c sysclk.c osc.c pll.h dfll.h sysclk.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/boards/sam4l_ek
    ../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c board_monitor.h led.h sam4l_ek.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/ast
    ../../../../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/gpio
    ../../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/eic
    ../../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usbc
    ../../../../../../../../../sam/drivers/usbc/: usbc_host.c usbc_otg.h usbc_host.h
  group sam/utils
    ../../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_ast.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ffconf.h ff.h diskio.h integer.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
