# IAR project host_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; RTC_CALENDAR_ASYNC=false; EXTINT_CALLBACK_MODE=true; UHD_ENABLE; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; USB_HOST_LPM_SUPPORT
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/port; ../../../../../hid/host/mouse; ../../../../../../../../../sam0/utils/cmsis/samr30/source; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../msc; ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../../../sam0/drivers/rtc/rtc_sam_l_c; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/usb; ../..; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/drivers/rtc; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/boards/samr30_xplained_pro; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../uhc; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../..; ../../../../../../../../../sam0/utils/cmsis/samr30/include; ../../../../../msc/host; ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/drivers/system/clock/clock_samr30; ../../../../../hid; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/drivers/system/clock; ../../../../../../../storage/ctrl_access; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example2_flash.bin
  ILINK.IlinkOutputFile: host_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h sbc_protocol.h spc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc_mem.h uhi_msc.h
  group common/services/usb/class/composite/host/example2
    ../../: main.c conf_fatfs.h conf_usb_host.h conf_access.h main.h ui.h
  group common/services/usb/class/composite/host/example2/samr30g18a_samr30_xplained_pro
    ../: ui.c conf_rtc.h conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/composite/host/example2/samr30g18a_samr30_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/drivers/rtc
    ../../../../../../../../../sam0/drivers/rtc/: rtc_calendar.h rtc_tamper.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../../../../../sam0/drivers/rtc/rtc_sam_l_c/: rtc_calendar.c
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../../../../sam0/drivers/system/clock/clock_samr30/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/boards/samr30_xplained_pro
    ../../../../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/: samr30.h samr30g18a.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/component/: mclk.h oscctrl.h tc.h nvmctrl.h port.h tcc.h ac.h supc.h pac.h rtc.h rstc.h usb.h dmac.h mtb.h dsu.h wdt.h ccl.h adc.h gclk.h osc32kctrl.h pm.h eic.h rfctrl.h tal.h sercom.h evsys.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30e18a.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/instance/: sercom0.h ccl.h sercom2.h rstc.h tc4.h osc32kctrl.h nvmctrl.h gclk.h sercom4.h pac.h tal.h sercom1.h sercom3.h port.h oscctrl.h tc0.h rfctrl.h dmac.h sercom5.h dsu.h tc1.h pm.h mtb.h mclk.h supc.h tcc1.h usb.h ac.h evsys.h wdt.h eic.h tcc0.h rtc.h tcc2.h adc.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ffconf.h ff.h diskio.h integer.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
