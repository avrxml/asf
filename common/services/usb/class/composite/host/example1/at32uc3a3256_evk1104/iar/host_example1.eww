<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\host_example1.ewp</path>
	</project>
</workspace>
