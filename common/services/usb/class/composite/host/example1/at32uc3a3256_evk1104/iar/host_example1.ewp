# IAR project host_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1104; ACCESS_MEM_TO_RAM_ENABLED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../hid/host/mouse; ../../../../../../../../../avr32/services/fs/fat; ../../../../../../../../../avr32/boards; ../../../../../msc; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/eic; ../..; ../../../../../../../../../avr32/boards/evk1104; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../uhc; ../../../../../../../clock; ..; ../../../../../..; ../../../../../msc/host; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1104; ACCESS_MEM_TO_RAM_ENABLED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/fs/fat
    ../../../../../../../../../avr32/services/fs/fat/: navigation.c fat_unusual.c file.c fat.c navigation.h file.h fat.h fs_com.h
  group avr32/drivers/eic
    ../../../../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_host.c usbb_otg.h usbb_host.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/boards/evk1104
    ../../../../../../../../../avr32/boards/evk1104/: init.c led.c led.h evk1104.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/usb/class/composite/host/example1
    ../../: main.c conf_access.h conf_explorer.h ui.h conf_usb_host.h main.h
  group common/services/usb/class/composite/host/example1/at32uc3a3256_evk1104
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clock.h
  group common/services/usb/class/composite/host/example1/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhc.h uhd.h uhi.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../clock/uc3a3_a4/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../boards/: board.h
