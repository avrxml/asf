<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\keyboard_example_flash.ewp</path>
	</project>
</workspace>
