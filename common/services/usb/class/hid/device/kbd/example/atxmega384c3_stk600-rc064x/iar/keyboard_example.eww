<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\keyboard_example.ewp</path>
	</project>
</workspace>
