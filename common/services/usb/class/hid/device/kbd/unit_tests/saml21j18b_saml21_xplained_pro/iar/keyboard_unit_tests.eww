<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\keyboard_unit_tests_flash.ewp</path>
	</project>
</workspace>
