<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\keyboard_unit_tests.ewp</path>
	</project>
</workspace>
