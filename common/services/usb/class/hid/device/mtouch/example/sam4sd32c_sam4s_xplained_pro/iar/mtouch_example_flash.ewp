# IAR project mtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_XPLAINED_PRO; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/boards/sam4s_xplained_pro; ..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../..; ../../../../../../../../../../sam/boards; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/drivers/wdt; ../../../../../../../../clock; ../../../../../../../../../../sam/drivers/matrix; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../..; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mtouch_example_flash.bin
  ILINK.IlinkOutputFile: mtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/matrix
    ../../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/wdt
    ../../../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s4a.h system_sam4s.h sam4sd32c.h sam4s4b.h sam4sa16b.h sam4s2b.h sam4s16c.h sam4s2a.h sam4s8b.h sam4sa16c.h sam4s4c.h sam4s2c.h sam4sd16c.h sam4sd32b.h sam4s16b.h sam4s8c.h sam4s.h sam4sd16b.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_pmc.h component_wdt.h component_spi.h component_usart.h component_gpbr.h component_pwm.h component_rtt.h component_twi.h component_adc.h component_matrix.h component_ssc.h component_rstc.h component_pio.h component_cmcc.h component_udp.h component_smc.h component_supc.h component_dacc.h component_hsmci.h component_chipid.h component_efc.h component_pdc.h component_rtc.h component_uart.h component_tc.h component_crccu.h component_acc.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_usart0.h instance_pwm.h instance_pmc.h instance_pioc.h instance_udp.h instance_pioa.h instance_hsmci.h instance_crccu.h instance_matrix.h instance_adc.h instance_twi1.h instance_dacc.h instance_efc1.h instance_uart1.h instance_rtt.h instance_twi0.h instance_cmcc.h instance_spi.h instance_tc0.h instance_tc1.h instance_acc.h instance_rtc.h instance_supc.h instance_chipid.h instance_smc.h instance_ssc.h instance_piob.h instance_wdt.h instance_rstc.h instance_usart1.h instance_uart0.h instance_efc0.h instance_gpbr.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16c.h pio_sam4sd16c.h pio_sam4s4a.h pio_sam4s8b.h pio_sam4sa16c.h pio_sam4s8c.h pio_sam4sd16b.h pio_sam4sd32c.h pio_sam4s2b.h pio_sam4sd32b.h pio_sam4s2c.h pio_sam4s2a.h pio_sam4s16b.h pio_sam4s4c.h pio_sam4sa16b.h pio_sam4s4b.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4s_xplained_pro
    ../../../../../../../../../../sam/boards/sam4s_xplained_pro/: init.c led.h sam4s_xplained_pro.h
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mtouch
    ../../../: udi_hid_multitouch_desc.c udi_hid_multitouch.c udi_hid_multitouch_conf.h udi_hid_multitouch.h
  group common/services/usb/class/hid/device/mtouch/example
    ../../: main.c conf_usb.h main.h ui.h
  group common/services/usb/class/hid/device/mtouch/example/sam4sd32c_sam4s_xplained_pro
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/mtouch/example/sam4sd32c_sam4s_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam4s
    ../../../../../../../../clock/sam4s/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
