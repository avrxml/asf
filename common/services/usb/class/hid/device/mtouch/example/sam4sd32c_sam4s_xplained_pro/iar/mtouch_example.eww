<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mtouch_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mtouch_example_sram.ewp</path>
	</project>
</workspace>
