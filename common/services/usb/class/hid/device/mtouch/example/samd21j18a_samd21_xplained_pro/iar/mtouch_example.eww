<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mtouch_example_flash.ewp</path>
	</project>
</workspace>
