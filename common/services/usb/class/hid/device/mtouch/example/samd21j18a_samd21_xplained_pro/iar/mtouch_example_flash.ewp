# IAR project mtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMD21_XPLAINED_PRO; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ..; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/usb; ../../..; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../sleepmgr; ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../utils; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../..; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/pinmux; ../..; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mtouch_example_flash.bin
  ILINK.IlinkOutputFile: mtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mtouch
    ../../../: udi_hid_multitouch.c udi_hid_multitouch_desc.c udi_hid_multitouch.h udi_hid_multitouch_conf.h
  group common/services/usb/class/hid/device/mtouch/example
    ../../: main.c conf_usb.h main.h ui.h
  group common/services/usb/class/hid/device/mtouch/example/samd21j18a_samd21_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/hid/device/mtouch/example/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21j18a.h samd21g17l.h samd21j16a.h samd21j17d.h samd21e16l.h samd21e15l.h samd21g18au.h samd21j15b.h samd21j16b.h samd21e16bu.h samd21.h samd21e17du.h samd21j15a.h samd21g16b.h samd21e17d.h samd21e17a.h samd21e15bu.h samd21e18a.h samd21g16a.h samd21g16l.h samd21e16a.h samd21e16b.h samd21e15b.h samd21g17a.h samd21e17l.h samd21g15b.h samd21e15a.h samd21g15a.h samd21g17d.h samd21j17a.h samd21g18a.h samd21g17au.h samd21g15l.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: nvmctrl_variant_d.h sbmatrix.h adc.h dmac.h tcc0.h tcc2.h tc4.h sercom0.h sercom3.h tc5.h pm.h sercom5.h nvmctrl.h tcc1.h tcc3.h port_variant_d.h port.h evsys_variant_d.h wdt.h tc7.h dsu.h usb.h sysctrl.h dac.h pac0.h sercom1.h evsys.h mtb.h rtc.h eic.h sercom2.h ac1.h sercom4.h tc6.h ac.h pac1.h tc3.h pac2.h gclk.h i2s.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21e17d.h samd21g16b.h samd21j18a.h samd21g15b.h samd21g16l.h samd21e15b.h samd21j17d.h samd21e16a.h samd21e16bu.h samd21j17a.h samd21j15a.h samd21g15a.h samd21j16b.h samd21g18au.h samd21e17du.h samd21g17l.h samd21e15bu.h samd21e15l.h samd21g18a.h samd21e16b.h samd21j16a.h samd21g17a.h samd21e18a.h samd21g15l.h samd21j15b.h samd21e16l.h samd21e15a.h samd21g16a.h samd21e17a.h samd21e17l.h samd21g17d.h samd21g17au.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: nvmctrl_variant_d.h dsu.h evsys_variant_d.h port.h pac.h tcc.h dmac.h usb.h sysctrl.h mtb.h eic.h tc.h i2s.h dac.h adc.h gclk.h ac.h wdt.h nvmctrl.h evsys.h pm.h rtc.h hmatrixb.h pm_variant_d.h tcc_lighting.h tcc_variant_d.h sercom.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h mrepeat.h mrecursion.h tpaste.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
