# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC4C__; BOARD=SAM4L_EK; UDD_ENABLE; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../../sam/utils/preprocessor; ../../..; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ..; ../../../../../../../../../../sam/drivers/eic; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../..; ../../../../../../../../../../sam/drivers/gpio; ../../../../../../../../delay; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../..; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../..; ../../../../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4LC4C__; BOARD=SAM4L_EK; UDD_ENABLE; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c udi_hid_generic.h udi_hid_generic_conf.h
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c ui.h main.h conf_usb.h
  group common/services/usb/class/hid/device/generic/example/sam4lc4c_sam4l_ek
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/generic/example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../../clock/: dfll.h pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../../clock/sam4l/: sysclk.c pll.c osc.c dfll.c genclk.h pll.h sysclk.h osc.h dfll.h
  group common/services/delay
    ../../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../../sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/gpio
    ../../../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/eic
    ../../../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/usbc
    ../../../../../../../../../../sam/drivers/usbc/: usbc_device.c usbc_otg.h usbc_device.h
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_ek
    ../../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c sam4l_ek.h board_monitor.h led.h
