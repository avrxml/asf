# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO_B; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; __SAML22N18A__
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/utils/cmsis/saml22/include; ../../..; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/usb; ..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam0/boards/saml22_xplained_pro_b; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22; ../../../../../../../../../../sam0/utils/cmsis/saml22/source; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../..; ../../../../../../../../../../sam0/drivers/system/clock/clock_saml22; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c udi_hid_generic.h udi_hid_generic_conf.h
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c conf_usb.h main.h ui.h
  group common/services/usb/class/hid/device/generic/example/saml22n18a_saml22_xplained_pro_b
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/hid/device/generic/example/saml22n18a_saml22_xplained_pro_b/iar
    ./: asf.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../../../../../sam0/drivers/system/clock/clock_saml22/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../../../../../sam0/utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../../../../../sam0/utils/cmsis/saml22/include/: saml22j17a.h saml22j18a.h saml22g17a.h saml22n16a.h saml22g16a.h saml22j16a.h saml22n18a.h saml22g18a.h saml22n17a.h saml22.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/saml22/include/instance/: tcc0.h usb.h oscctrl.h sercom0.h pac.h sercom2.h mtb.h trng.h tc0.h ccl.h tal.h sercom1.h tc3.h tc1.h slcd.h sercom3.h sercom4.h sercom5.h osc32kctrl.h dmac.h rtc.h pm.h mclk.h gclk.h ac.h rstc.h adc.h freqm.h eic.h tc2.h aes.h wdt.h dsu.h nvmctrl.h supc.h evsys.h port.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../../../../../sam0/utils/cmsis/saml22/include/component/: adc.h tcc.h trng.h pm.h mtb.h wdt.h ccl.h tc.h evsys.h pac.h osc32kctrl.h rstc.h slcd.h usb.h mclk.h rtc.h supc.h freqm.h sercom.h nvmctrl.h oscctrl.h aes.h ac.h dmac.h dsu.h gclk.h tal.h port.h eic.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/saml22/include/pio/: saml22g18a.h saml22j16a.h saml22j17a.h saml22g17a.h saml22j18a.h saml22g16a.h saml22n17a.h saml22n18a.h saml22n16a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrecursion.h mrepeat.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../../../../../sam0/boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
