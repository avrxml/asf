<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\generic_example.ewp</path>
	</project>
</workspace>
