# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../..; ../../../../../../../../ioport; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../udc; ../..; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../..; ../../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c udi_hid_generic.h udi_hid_generic_conf.h
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c conf_usb.h main.h ui.h
  group common/services/usb/class/hid/device/generic/example/sam3u4e_sam3u_ek
    ../: ui.c conf_board.h conf_clock.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/generic/example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam3u
    ../../../../../../../../clock/sam3u/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/: sam3u4c.h sam3u2e.h sam3u4e.h sam3u1c.h sam3u.h sam3u1e.h sam3u2c.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_gpbr.h instance_hsmci.h instance_usart1.h instance_supc.h instance_usart3.h instance_efc0.h instance_twi1.h instance_piob.h instance_wdt.h instance_dmac.h instance_rstc.h instance_udphs.h instance_rtc.h instance_twi0.h instance_adc.h instance_smc.h instance_tc0.h instance_efc1.h instance_pioa.h instance_pwm.h instance_rtt.h instance_ssc.h instance_uart.h instance_adc12b.h instance_pmc.h instance_usart0.h instance_usart2.h instance_matrix.h instance_spi.h instance_chipid.h instance_pioc.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/component/: component_udphs.h component_spi.h component_twi.h component_supc.h component_rtc.h component_uart.h component_dmac.h component_adc.h component_hsmci.h component_adc12b.h component_rstc.h component_wdt.h component_smc.h component_chipid.h component_pdc.h component_pio.h component_pmc.h component_usart.h component_pwm.h component_efc.h component_gpbr.h component_ssc.h component_rtt.h component_matrix.h component_tc.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2c.h pio_sam3u2e.h pio_sam3u1c.h pio_sam3u1e.h pio_sam3u4c.h pio_sam3u4e.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/udphs
    ../../../../../../../../../../sam/drivers/udphs/: udphs_device.c udphs_device.h
  group sam/boards/sam3u_ek
    ../../../../../../../../../../sam/boards/sam3u_ek/: init.c led.c sam3u_ek.h led.h
