<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\generic_example_flash.ewp</path>
	</project>
</workspace>
