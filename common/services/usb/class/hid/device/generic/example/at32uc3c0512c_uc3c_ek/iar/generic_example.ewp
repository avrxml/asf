# IAR project generic_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../../avr32/drivers/pm; ..; ../../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../../avr32/boards/uc3c_ek; ../../../..; ../../../../../../../../clock; ../../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../../boards; ../..; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../avr32/utils; ../../..; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../avr32/drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/uc3c
    ../../../../../../../../clock/uc3c/: sysclk.c pll.c osc.c pll.h sysclk.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c udi_hid_generic.h udi_hid_generic_conf.h
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c ui.h conf_usb.h main.h
  group common/services/usb/class/hid/device/generic/example/at32uc3c0512c_uc3c_ek
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/generic/example/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c pm_uc3c.h sleep.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbc
    ../../../../../../../../../../avr32/drivers/usbc/: usbc_device.c usbc_device.h usbc_otg.h
  group avr32/drivers/scif
    ../../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/eic
    ../../../../../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/uc3c_ek
    ../../../../../../../../../../avr32/boards/uc3c_ek/: led.c init.c uc3c_ek.h led.h
  group avr32/utils
    ../../../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
