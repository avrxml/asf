# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; UDD_ENABLE; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../../../../sam/drivers/pmc; ../../..; ../../../../../../../../../../sam/utils/cmsis/same70/include; ../../../../../../../../../../sam/utils/fpu; ../../../../../../../../../../sam/drivers/mpu; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/boards/same70_xplained; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../..; ../../../../../../../../../../sam/drivers/usbhs; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils; ..; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../..; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../../clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/same70
    ../../../../../../../../clock/same70/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c udi_hid_generic.h udi_hid_generic_conf.h
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c main.h conf_usb.h ui.h
  group common/services/usb/class/hid/device/generic/example/same70q21_same70_xplained
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/generic/example/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usbhs
    ../../../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_device.h usbhs_otg.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/mpu
    ../../../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/boards/same70_xplained
    ../../../../../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../../../sam/utils/cmsis/same70/include/: same70q21.h same70q21b.h same70j21b.h same70j19b.h same70n20b.h same70q19b.h same70n21b.h same70j20.h same70j19.h same70n19.h same70q20.h same70n20.h same70q20b.h same70j21.h same70.h same70n19b.h same70n21.h same70q19.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../../../sam/utils/cmsis/same70/include/instance/: uart3.h tc1.h ssc.h uart1.h tc3.h aes.h uart0.h rtc.h pmc.h xdmac.h usart2.h usart1.h usart0.h acc.h piod.h supc.h piob.h mcan1.h matrix.h efc.h rtt.h spi1.h pwm1.h tc2.h icm.h afec1.h afec0.h hsmci.h i2sc0.h rstc.h i2sc1.h spi0.h usbhs.h twihs2.h utmi.h twihs0.h isi.h dacc.h trng.h pwm0.h smc.h tc0.h rswdt.h uart4.h sdramc.h gpbr.h twihs1.h chipid.h pioe.h qspi.h gmac.h pioc.h uart2.h wdt.h pioa.h mcan0.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70n19.h same70q19.h same70j21.h same70j20b.h same70j19b.h same70n20.h same70q21b.h same70n21b.h same70j19.h same70q19b.h same70q21.h same70n19b.h same70n20b.h same70q20.h same70j20.h same70j21b.h same70n21.h same70q20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../../../sam/utils/cmsis/same70/include/component/: rtc.h aes.h gpbr.h icm.h usbhs.h efc.h trng.h pmc.h dacc.h matrix.h usart.h uart.h pwm.h wdt.h spi.h gmac.h ssc.h chipid.h acc.h hsmci.h rstc.h twihs.h xdmac.h i2sc.h pio.h isi.h rswdt.h supc.h qspi.h rtt.h tc.h afec.h mcan.h utmi.h smc.h sdramc.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/fpu
    ../../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
