# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; USART_CALLBACK_MODE=true; __SAML21J18B__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/port; ../..; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/boards/saml21_xplained_pro_b; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../serial; ../../../../../../../../../../sam0/utils/cmsis/saml21/include_b; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../..; ../../../../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/usb; ../../..; ..; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/saml21j18b_saml21_xplained_pro
    ../: conf_sleepmgr.h conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group common/services/usb/class/hid/device/mouse/unit_tests/saml21j18b_saml21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udd.h udc_desc.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_interrupt.h sercom_pinout.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e16b.h saml21g17b.h saml21j17b.h saml21e17b.h saml21e15b.h saml21e18b.h saml21g18b.h saml21g16b.h saml21j16b.h saml21.h saml21j18b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: pac.h rstc.h evsys.h tc3.h trng.h tcc1.h eic.h pm.h sercom5.h gclk.h sercom2.h sercom4.h ccl.h dmac.h nvmctrl.h mtb.h tal.h tcc2.h rtc.h osc32kctrl.h sercom0.h sercom3.h tcc0.h oscctrl.h opamp.h tc0.h port.h sercom1.h adc.h supc.h tc1.h dac.h tc4.h tc2.h aes.h usb.h dsu.h mclk.h wdt.h ac.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../../../../../sam0/utils/cmsis/saml21/include_b/component/: nvmctrl.h ccl.h rstc.h pm.h usb.h pac.h tal.h opamp.h osc32kctrl.h mclk.h eic.h oscctrl.h dsu.h dac.h trng.h tc.h evsys.h aes.h ac.h dmac.h rtc.h wdt.h gclk.h supc.h adc.h port.h sercom.h mtb.h tcc.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21e18b.h saml21j17b.h saml21g17b.h saml21j16b.h saml21j18b.h saml21g16b.h saml21g18b.h saml21e15b.h saml21e17b.h saml21e16b.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrecursion.h mrepeat.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
