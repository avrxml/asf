# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; UDD_ENABLE; ARM_MATH_CM3=true; __SAM3U4E__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ..; ../../../..; ../../../../../../../../serial; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../..; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../..; ../../../../../../../../gpio; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../../../../../udc; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group common/services/usb/class/hid/device/mouse/unit_tests/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam3u
    ../../../../../../../../clock/sam3u/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/: sam3u4c.h sam3u2e.h sam3u4e.h sam3u1c.h sam3u.h sam3u1e.h sam3u2c.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_gpbr.h instance_hsmci.h instance_usart1.h instance_supc.h instance_usart3.h instance_efc0.h instance_twi1.h instance_piob.h instance_wdt.h instance_dmac.h instance_rstc.h instance_udphs.h instance_rtc.h instance_twi0.h instance_matrix.h instance_adc.h instance_smc.h instance_tc0.h instance_efc1.h instance_pioa.h instance_pwm.h instance_rtt.h instance_ssc.h instance_uart.h instance_adc12b.h instance_pmc.h instance_usart0.h instance_usart2.h instance_spi.h instance_chipid.h instance_pioc.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/component/: component_udphs.h component_spi.h component_twi.h component_supc.h component_uart.h component_dmac.h component_rtc.h component_adc.h component_hsmci.h component_adc12b.h component_rstc.h component_wdt.h component_smc.h component_chipid.h component_pdc.h component_pio.h component_pmc.h component_usart.h component_pwm.h component_efc.h component_gpbr.h component_ssc.h component_rtt.h component_matrix.h component_tc.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2c.h pio_sam3u2e.h pio_sam3u1c.h pio_sam3u1e.h pio_sam3u4c.h pio_sam3u4e.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/udphs
    ../../../../../../../../../../sam/drivers/udphs/: udphs_device.c udphs_device.h
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/boards/sam3u_ek
    ../../../../../../../../../../sam/boards/sam3u_ek/: init.c led.c sam3u_ek.h led.h
