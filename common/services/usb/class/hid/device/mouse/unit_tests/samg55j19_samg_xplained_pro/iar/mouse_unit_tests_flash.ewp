# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; _ASSERT_ENABLE_; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/drivers/flexcom; ../../../../../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../../../../../sam/drivers/efc; ../../../../../../../../../../sam/utils/fpu; ../../../../../../../../serial; ../../../../../../../../../../sam/drivers/supc; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates; ../../..; ../../../../../../../../clock; ../../../../../../../../../../sam/drivers/matrix; ../../../../../../../../../../sam/boards; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; ../../../../../../../../../../sam/utils/cmsis/samg/samg55/include; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h genclk.h osc.h
  group common/services/clock/samg
    ../../../../../../../../clock/samg/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc_desc.h udd.h udc.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/samg55j19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group common/services/usb/class/hid/device/mouse/unit_tests/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/supc
    ../../../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/flexcom
    ../../../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/matrix
    ../../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55g19.h samg55g18.h samg55j18.h samg55.h samg55j19.h system_samg55.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: twi5.h spi6.h pioa.h i2sc1.h pmc.h i2sc0.h flexcom1.h flexcom7.h usart5.h twi1.h usart0.h flexcom5.h flexcom2.h twi3.h adc.h twi4.h rstc.h spi3.h spi1.h uhp.h pdmic0.h rtc.h tc0.h flexcom3.h udp.h flexcom0.h gpbr.h flexcom6.h twi2.h pdmic1.h flexcom4.h spi2.h spi0.h tc1.h rtt.h twi0.h wdt.h mem2mem.h cmcc.h chipid.h efc.h twi7.h spi4.h usart2.h spi5.h usart1.h supc.h crccu.h piob.h matrix.h usart4.h usart7.h usart6.h twi6.h spi7.h usart3.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: rtt.h udp.h twi.h usart.h flexcom.h wdt.h pio.h uhp.h rtc.h adc.h mem2mem.h crccu.h supc.h pdc.h pdmic.h i2sc.h chipid.h tc.h efc.h pmc.h gpbr.h cmcc.h matrix.h spi.h rstc.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55n19.h samg55g18.h samg55g19.h samg55j18.h samg55j19.h
  group sam/utils/fpu
    ../../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../../../../../sam/boards/samg55_xplained_pro/: board_init.c led.h samg55_xplained_pro.h
