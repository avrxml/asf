# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; UDD_ENABLE; __SAME70Q21B__; BOARD=SAME70_XPLAINED; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/utils/cmsis/same70/source/templates; ..; ../../../../../../../../../../sam/utils/cmsis/same70/include; ../../../../../../../../../../sam/utils/fpu; ../../../../../../../../serial; ../../../../../../../../../../sam/drivers/mpu; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/boards/same70_xplained; ../../..; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../../../sam/drivers/pio; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/usbhs; ../../../../../../../../gpio; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pmc; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_board.h conf_sleepmgr.h conf_test.h conf_clock.h
  group common/services/usb/class/hid/device/mouse/unit_tests/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/clock
    ../../../../../../../../clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/same70
    ../../../../../../../../clock/same70/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/usbhs
    ../../../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_device.h usbhs_otg.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/mpu
    ../../../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/boards/same70_xplained
    ../../../../../../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../../../sam/utils/cmsis/same70/include/: same70q21.h same70q21b.h same70j19b.h same70n20b.h same70q19b.h same70n21b.h same70j20.h same70j19.h same70q20.h same70n19.h same70n20.h same70q20b.h same70j21.h same70.h same70j21b.h same70n19b.h same70n21.h same70q19.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../../../sam/utils/cmsis/same70/include/instance/: uart3.h tc1.h ssc.h uart1.h aes.h uart0.h rtc.h pmc.h xdmac.h usart2.h usart1.h usart0.h acc.h piod.h supc.h piob.h mcan1.h matrix.h efc.h tc3.h rtt.h spi1.h pwm1.h tc2.h icm.h afec1.h afec0.h tc0.h hsmci.h i2sc0.h rstc.h i2sc1.h spi0.h usbhs.h twihs2.h utmi.h twihs0.h uart4.h isi.h dacc.h trng.h pwm0.h smc.h rswdt.h sdramc.h gpbr.h twihs1.h chipid.h pioe.h qspi.h gmac.h pioc.h uart2.h wdt.h pioa.h mcan0.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70n19.h same70q19.h same70j21.h same70j20b.h same70j19b.h same70n20.h same70q21b.h same70n21b.h same70j19.h same70q19b.h same70q21.h same70n19b.h same70q20.h same70j20.h same70n20b.h same70j21b.h same70n21.h same70q20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../../../sam/utils/cmsis/same70/include/component/: rtc.h aes.h usart.h gpbr.h icm.h usbhs.h efc.h trng.h pmc.h dacc.h matrix.h uart.h pwm.h wdt.h spi.h gmac.h ssc.h chipid.h acc.h hsmci.h rstc.h twihs.h xdmac.h i2sc.h pio.h isi.h rswdt.h supc.h qspi.h rtt.h tc.h afec.h mcan.h utmi.h smc.h sdramc.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/fpu
    ../../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
