<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mouse_unit_tests.ewp</path>
	</project>
</workspace>
