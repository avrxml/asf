# IAR project mouse_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; BOARD=EVK1104; TEST_SUITE_DEFINE_ASSERT_MACRO; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../../../serial; ../../../../../../../../../../avr32/boards/evk1104; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../..; ../../../../../../../../clock; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../udc; ../../../../../../..; ../../../..; ../../../../../../../../serial/uc3_usart; ../../../../../../../../../boards; ..; ../../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse.c udi_hid_mouse_desc.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/at32uc3a3256_evk1104
    ../: conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group common/services/usb/class/hid/device/mouse/unit_tests/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../../serial/uc3_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../../clock/uc3a3_a4/: sysclk.c osc.h genclk.h pll.h sysclk.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group avr32/drivers/usbb
    ../../../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/evk1104
    ../../../../../../../../../../avr32/boards/evk1104/: led.c init.c evk1104.h led.h
  group avr32/utils
    ../../../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
