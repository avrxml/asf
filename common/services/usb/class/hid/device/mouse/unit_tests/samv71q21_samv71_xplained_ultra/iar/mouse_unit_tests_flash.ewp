# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; UDD_ENABLE; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAMV71Q21B__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/utils/fpu; ../../../../../../../../serial; ../../../../../../../../../../sam/drivers/mpu; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/utils/cmsis/samv71/source/templates; ../../..; ../../../../../../../../../../sam/boards/samv71_xplained_ultra; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ..; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/usbhs; ../../../../../../../../gpio; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; ../../../../../../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/samv71q21_samv71_xplained_ultra
    ../: conf_test.h conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/mouse/unit_tests/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udi.h udd.h udc.h udc_desc.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../../clock/: osc.h sysclk.h genclk.h pll.h
  group common/services/clock/samv71
    ../../../../../../../../clock/samv71/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../../../../../sam/boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/usbhs
    ../../../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_device.h usbhs_otg.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/mpu
    ../../../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../../../../../sam/utils/cmsis/samv71/include/: samv71j20b.h samv71n19b.h samv71j20.h samv71n21b.h samv71j21.h samv71j19.h samv71q21b.h samv71.h samv71q21.h samv71n20b.h samv71n20.h samv71j21b.h samv71q19.h samv71q19b.h samv71q20b.h samv71q20.h samv71n19.h samv71j19b.h samv71n21.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../../../../../sam/utils/cmsis/samv71/include/component/: usbhs.h acc.h utmi.h rtt.h pio.h tc.h wdt.h i2sc.h pwm.h uart.h rstc.h pmc.h isi.h afec.h mcan.h matrix.h efc.h hsmci.h rswdt.h mlb.h qspi.h chipid.h dacc.h icm.h trng.h twihs.h gmac.h sdramc.h aes.h rtc.h spi.h usart.h xdmac.h supc.h smc.h ssc.h gpbr.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71q21.h samv71q20.h samv71n20b.h samv71q19.h samv71q19b.h samv71j19b.h samv71n19.h samv71j20b.h samv71n21.h samv71n19b.h samv71q21b.h samv71n20.h samv71j21.h samv71j19.h samv71q20b.h samv71n21b.h samv71j21b.h samv71j20.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../../../../../sam/utils/cmsis/samv71/include/instance/: dacc.h pioa.h pwm0.h twihs1.h pioc.h xdmac.h gpbr.h ssc.h acc.h supc.h pioe.h rtt.h mcan1.h uart3.h smc.h sdramc.h piob.h rtc.h aes.h usart0.h i2sc0.h piod.h usart2.h gmac.h tc0.h trng.h rswdt.h icm.h afec0.h uart1.h twihs2.h hsmci.h mlb.h efc.h mcan0.h uart4.h utmi.h i2sc1.h pmc.h tc2.h matrix.h usart1.h isi.h usbhs.h qspi.h tc1.h uart2.h afec1.h uart0.h pwm1.h rstc.h twihs0.h spi0.h chipid.h spi1.h wdt.h tc3.h
  group sam/utils/fpu
    ../../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
