# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; UDD_ENABLE; __SAM4LC8C__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../..; ../../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../serial; ../../../../../../../../../../sam/drivers/eic; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/drivers/wdt; ../../..; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../utils/stdio/stdio_serial; ..; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/gpio; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/boards/sam4l8_xplained_pro; ../../../../..; ../../../../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/sam4lc8c_sam4l8_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group common/services/usb/class/hid/device/mouse/unit_tests/sam4lc8c_sam4l8_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/clock
    ../../../../../../../../clock/: dfll.h pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../../clock/sam4l/: sysclk.c pll.c osc.c dfll.c pll.h osc.h sysclk.h genclk.h dfll.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../../sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/gpio
    ../../../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/eic
    ../../../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/usbc
    ../../../../../../../../../../sam/drivers/usbc/: usbc_device.c usbc_device.h usbc_otg.h
  group sam/drivers/wdt
    ../../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4lc8a.h sam4lc4a.h sam4ls4b.h sam4lc8c.h sam4l.h sam4ls4a.h sam4lc2c.h sam4lc2a.h sam4ls2a.h sam4ls2c.h sam4ls8c.h sam4ls8a.h sam4lc2b.h sam4lc4c.h sam4ls2b.h sam4ls8b.h sam4ls4c.h sam4lc8b.h sam4lc4b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_usart3.h instance_catb.h instance_tc0.h instance_smap.h instance_acifc.h instance_hcache.h instance_pm.h instance_scif.h instance_parc.h instance_tc1.h instance_freqm.h instance_pevc.h instance_adcife.h instance_wdt.h instance_twim2.h instance_bpm.h instance_aesa.h instance_gpio.h instance_trng.h instance_gloc.h instance_dacc.h instance_chipid.h instance_twis1.h instance_iisc.h instance_twim0.h instance_twis0.h instance_eic.h instance_crccu.h instance_usbc.h instance_twim3.h instance_hmatrix.h instance_ast.h instance_picouart.h instance_usart0.h instance_twim1.h instance_usart2.h instance_abdacb.h instance_lcdca.h instance_bscif.h instance_spi.h instance_pdca.h instance_hflashc.h instance_usart1.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_eic.h component_flashcalw.h component_trng.h component_abdacb.h component_freqm.h component_hcache.h component_pdca.h component_bscif.h component_usbc.h component_pm.h component_twis.h component_catb.h component_picouart.h component_hmatrixb.h component_smap.h component_scif.h component_gloc.h component_lcdca.h component_crccu.h component_twim.h component_aesa.h component_dacc.h component_adcife.h component_pevc.h component_spi.h component_iisc.h component_usart.h component_acifc.h component_gpio.h component_parc.h component_wdt.h component_bpm.h component_ast.h component_tc.h component_chipid.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4ls2b.h pio_sam4ls8b.h pio_sam4ls8c.h pio_sam4lc2b.h pio_sam4lc4b.h pio_sam4lc8c.h pio_sam4lc8a.h pio_sam4ls8a.h pio_sam4ls4c.h pio_sam4ls4a.h pio_sam4lc8b.h pio_sam4ls4b.h pio_sam4ls2a.h pio_sam4ls2c.h pio_sam4lc4c.h pio_sam4lc2a.h pio_sam4lc4a.h pio_sam4lc2c.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../../../../../../sam/boards/sam4l8_xplained_pro/: init.c led.h sam4l8_xplained_pro.h
