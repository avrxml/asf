# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; UDD_ENABLE; __SAM4E16E__; BOARD=SAM4E_XPLAINED_PRO; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../serial/sam_uart; ../..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/boards/sam4e_xplained_pro; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/utils/fpu; ../../../../../../../../serial; ../../../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ..; ../../..; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/sam4e16e_sam4e_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group common/services/usb/class/hid/device/mouse/unit_tests/sam4e16e_sam4e_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam4e
    ../../../../../../../../clock/sam4e/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e8c.h sam4e16c.h sam4e.h sam4e16e.h sam4e8e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../../../../sam/utils/cmsis/sam4e/include/component/: rtt.h pdc.h aes.h can.h efc.h pio.h acc.h pwm.h cmcc.h tc.h uart.h rswdt.h usart.h twi.h pmc.h dacc.h afec.h hsmci.h wdt.h dmac.h spi.h smc.h gpbr.h gmac.h supc.h rstc.h rtc.h chipid.h matrix.h udp.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e8c.h sam4e16c.h sam4e8e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../../../../sam/utils/cmsis/sam4e/include/instance/: smc.h rswdt.h gpbr.h cmcc.h wdt.h piob.h pwm.h can1.h rtc.h can0.h aes.h dacc.h piod.h rtt.h twi0.h tc1.h rstc.h pioc.h afec1.h chipid.h udp.h pmc.h uart0.h pioe.h twi1.h tc0.h gmac.h afec0.h pioa.h usart1.h tc2.h dmac.h efc.h uart1.h matrix.h acc.h supc.h usart0.h hsmci.h spi.h
  group sam/utils/fpu
    ../../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../../../../../../sam/boards/sam4e_xplained_pro/: init.c led.h sam4e_xplained_pro.h
