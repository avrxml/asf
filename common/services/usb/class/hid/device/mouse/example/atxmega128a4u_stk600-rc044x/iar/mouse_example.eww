<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mouse_example.ewp</path>
	</project>
</workspace>
