# IAR project mouse_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../../../../../../xmega/drivers/usb; ../../../..; ../../../../../../../../clock; ../../../../../../../../../boards; ../../../../../../../../../../xmega/drivers/nvm; ..; ../../../../../../../../../../xmega/utils/preprocessor; ../..; ../../../../../../../../../../xmega/utils; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../gpio; ../../../../../../../../../utils; ../../../../../../../../../../xmega/boards; ../../../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../../xmega/drivers/cpu; ../../../../../../../../ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/usb/class/hid/device/mouse/example
    ../../: main.c conf_usb.h ui.h main.h
  group common/services/usb/class/hid/device/mouse/example/atxmega128b1_xmega_b1_xplained
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clock.h
  group common/services/usb/class/hid/device/mouse/example/atxmega128b1_xmega_b1_xplained/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/services/clock
    ../../../../../../../../clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/boards/xmega_b1_xplained
    ../../../../../../../../../../xmega/boards/xmega_b1_xplained/: init.c led.h xmega_b1_xplained.h
  group xmega/utils
    ../../../../../../../../../../xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/bit_handling
    ../../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../../../../../xmega/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group xmega/utils/assembler
    ../../../../../../../../../../xmega/utils/assembler/: iar.h
