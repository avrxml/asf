# IAR project mouse_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UDD_ENABLE; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../../avr32/drivers/flashc; ../../..; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../../avr32/drivers/gpio; ../../../..; ../../../../../../../../clock; ../../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../boards; ../../../../../../../../../../avr32/boards; ../..; ..; ../../../../../../../../../../avr32/components/joystick/skrhabe010; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/boards/evk1100; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../avr32/drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UDD_ENABLE; BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/usb/class/hid/device/mouse/example
    ../../: main.c ui.h conf_usb.h main.h
  group common/services/usb/class/hid/device/mouse/example/at32uc3a0512_evk1100
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/device/mouse/example/at32uc3a0512_evk1100/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udc_desc.h udi.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3a0_a1
    ../../../../../../../../clock/uc3a0_a1/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group avr32/drivers/usbb
    ../../../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/eic
    ../../../../../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/evk1100
    ../../../../../../../../../../avr32/boards/evk1100/: led.c init.c led.h evk1100.h
  group avr32/utils
    ../../../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/components/joystick/skrhabe010
    ../../../../../../../../../../avr32/components/joystick/skrhabe010/: joystick.h
