<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mouse_example_flash.ewp</path>
	</project>
</workspace>
