# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMDA1J16A__; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; BOARD=SAMDA1_XPLAINED_PRO; UHD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; USB_HOST_LPM_SUPPORT
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/system/power; ../../../../../host/mouse; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../../sam0/utils/cmsis/samda1/include; ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../sleepmgr; ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../device/mouse; ../../../../../../../uhc; ../..; ../../../../../../../../../../sam0/boards/samda1_xplained_pro; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../utils; ..; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../device; ../../../../../../../../../../sam0/utils/cmsis/samda1/source; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/hid/dual/mouse/example
    ../../: main.c conf_usb_host.h conf_usb.h main.h ui.h
  group common/services/usb/class/hid/dual/mouse/example/samda1j16a_samda1_xplained_pro
    ../: ui.c conf_extint.h conf_board.h conf_sleepmgr.h conf_clocks.h
  group common/services/usb/class/hid/dual/mouse/example/samda1j16a_samda1_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_host_uhd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../../../../../sam0/utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/: samda1g15a.h samda1j14b.h samda1e16a.h samda1e14b.h samda1g15b.h samda1j16b.h samda1g16a.h samda1e15a.h samda1.h samda1j15b.h samda1e14a.h samda1e15b.h samda1g14b.h samda1j15a.h samda1j16a.h samda1j14a.h samda1g14a.h samda1e16b.h samda1g16b.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/pio/: samda1g16a.h samda1j15b.h samda1g16b.h samda1e14b.h samda1j16b.h samda1e15b.h samda1e15a.h samda1g15b.h samda1j14b.h samda1j16a.h samda1g15a.h samda1j14a.h samda1g14a.h samda1j15a.h samda1e16a.h samda1g14b.h samda1e14a.h samda1e16b.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/instance/: mtb.h sercom5.h sercom4.h sercom3.h tc3.h pac1.h sercom1.h dac.h i2s.h tc7.h port.h tcc2.h pac2.h nvmctrl.h pm.h pac0.h tcc1.h ac.h tcc0.h dsu.h sysctrl.h sbmatrix.h gclk.h tc5.h evsys.h dmac.h eic.h rtc.h wdt.h sercom2.h tc4.h sercom0.h usb.h adc.h tc6.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/component/: gclk.h i2s.h dac.h pm.h tcc.h hmatrixb.h dsu.h pac.h wdt.h sysctrl.h port.h sercom.h nvmctrl.h adc.h rtc.h evsys.h mtb.h dmac.h eic.h tc.h ac.h usb.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h mrecursion.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../../../../../../sam0/boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
