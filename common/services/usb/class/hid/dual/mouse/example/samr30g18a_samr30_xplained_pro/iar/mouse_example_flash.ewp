# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; UHD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; BOARD=SAMR30_XPLAINED_PRO; USB_HOST_LPM_SUPPORT
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/system/power; ../../../../../host/mouse; ../../../../../../../../../../sam0/utils/cmsis/samr30/source; ..; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam0/boards/samr30_xplained_pro; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../../uhc; ../..; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam0/utils/cmsis/samr30/include; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../device; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../device/mouse; ../../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../../sam0/drivers/system/clock/clock_samr30; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/usb/class/hid/dual/mouse/example
    ../../: main.c conf_usb_host.h conf_usb.h main.h ui.h
  group common/services/usb/class/hid/dual/mouse/example/samr30g18a_samr30_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/hid/dual/mouse/example/samr30g18a_samr30_xplained_pro/iar
    ./: asf.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samr30/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_host_uhd.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/boards/samr30_xplained_pro
    ../../../../../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../../../../../sam0/utils/cmsis/samr30/include/: samr30g18a.h samr30.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samr30/include/instance/: sercom4.h eic.h evsys.h adc.h dsu.h tal.h tc1.h rfctrl.h sercom0.h ac.h sercom2.h nvmctrl.h rtc.h tc0.h ccl.h supc.h usb.h mclk.h gclk.h tcc2.h oscctrl.h port.h tcc0.h sercom5.h osc32kctrl.h pm.h tc4.h wdt.h pac.h sercom3.h sercom1.h mtb.h rstc.h tcc1.h dmac.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samr30/include/component/: gclk.h tal.h sercom.h mclk.h port.h adc.h mtb.h ccl.h osc32kctrl.h evsys.h rstc.h oscctrl.h dsu.h tcc.h supc.h nvmctrl.h eic.h wdt.h usb.h dmac.h tc.h rtc.h rfctrl.h pm.h pac.h ac.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrecursion.h mrepeat.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
