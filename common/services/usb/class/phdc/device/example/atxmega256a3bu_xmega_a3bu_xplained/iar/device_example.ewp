# IAR project device_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../clock; ../../..; ..; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../gpio; ../../../..; ../../../../../../../../boards; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../../xmega/utils; ../../../../../../udc; ../../../../../..; ../../../../../../../../utils; ../../../../../../../../../xmega/boards; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../sleepmgr; ../../../../../../../../../xmega/drivers/sleep; ../..; ../../../../../../../../../xmega/drivers/cpu; ../../../../../../../ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/usb/class/phdc
    ../../../../: usb_protocol_phdc.h
  group common/services/usb/class/phdc/device
    ../../../: udi_phdc_desc.c udi_phdc.c udi_phdc_conf.h udi_phdc.h
  group common/services/usb/class/phdc/device/example
    ../../: ieee11073_skeleton.c main.c ui.h conf_usb.h ieee11073_skeleton.h main.h
  group common/services/usb/class/phdc/device/example/atxmega256a3bu_xmega_a3bu_xplained
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/phdc/device/example/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/utils
    ../../../../../../../../../xmega/utils/: compiler.h assembler.h progmem.h status_codes.h
  group xmega/utils/preprocessor
    ../../../../../../../../../xmega/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../../../xmega/utils/assembler/: iar.h
