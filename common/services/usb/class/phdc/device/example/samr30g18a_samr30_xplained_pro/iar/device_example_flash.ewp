# IAR project device_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; BOARD=SAMR30_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/utils/cmsis/samr30/source; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../../sam0/boards; ../../..; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/boards/samr30_xplained_pro; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../..; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam0/utils/cmsis/samr30/include; ../..; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ..; ../../../../../../../../../sam0/drivers/system/clock/clock_samr30; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example_flash.bin
  ILINK.IlinkOutputFile: device_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/phdc
    ../../../../: usb_protocol_phdc.h
  group common/services/usb/class/phdc/device
    ../../../: udi_phdc_desc.c udi_phdc.c udi_phdc.h udi_phdc_conf.h
  group common/services/usb/class/phdc/device/example
    ../../: ieee11073_skeleton.c main.c conf_usb.h main.h ui.h ieee11073_skeleton.h
  group common/services/usb/class/phdc/device/example/samr30g18a_samr30_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/phdc/device/example/samr30g18a_samr30_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/: samr30.h samr30g18a.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/component/: mclk.h nvmctrl.h oscctrl.h sercom.h tc.h ccl.h port.h tcc.h ac.h supc.h pac.h rtc.h rstc.h gclk.h usb.h dmac.h mtb.h dsu.h wdt.h adc.h osc32kctrl.h pm.h eic.h tal.h rfctrl.h evsys.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30e18a.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/instance/: sercom0.h ccl.h sercom2.h evsys.h rstc.h tc4.h osc32kctrl.h nvmctrl.h gclk.h sercom4.h pac.h tal.h sercom1.h sercom3.h port.h oscctrl.h tc0.h rfctrl.h dmac.h sercom5.h pm.h tc1.h dsu.h mtb.h mclk.h supc.h tcc1.h usb.h ac.h wdt.h eic.h tcc0.h rtc.h tcc2.h adc.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../../../../sam0/drivers/system/clock/clock_samr30/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
