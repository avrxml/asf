<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_example3.ewp</path>
	</project>
</workspace>
