# IAR project device_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; UDD_ENABLE; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/utils/cmsis/same70/include; ../../../../../../../../../sam/utils/fpu; ../../../../../../../../../sam/drivers/mpu; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam/boards/same70_xplained; ../../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/usbhs; ../..; ../../../../../../../gpio; ../../../../../../../../../sam/utils; ..; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example_flash.bin
  ILINK.IlinkOutputFile: device_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/class/cdc/device/example
    ../../: uart_sam.c main.c uart.h main.h conf_usb.h ui.h
  group common/services/usb/class/cdc/device/example/same70q21_same70_xplained
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/usb/class/cdc/device/example/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/same70
    ../../../../../../../clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/mpu
    ../../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usbhs
    ../../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/same70_xplained
    ../../../../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../../sam/utils/cmsis/same70/include/: same70.h same70n19.h same70n20b.h same70q19b.h same70n20.h same70n19b.h same70q20b.h same70j19.h same70j21b.h same70q21b.h same70q20.h same70n21b.h same70j21.h same70j19b.h same70q19.h same70j20b.h same70q21.h same70j20.h same70n21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../../sam/utils/cmsis/same70/include/instance/: pioe.h hsmci.h mcan0.h i2sc1.h pioc.h pmc.h pioa.h afec1.h rswdt.h usbhs.h usart2.h uart3.h efc.h icm.h uart1.h matrix.h usart0.h isi.h qspi.h sdramc.h wdt.h i2sc0.h dacc.h smc.h rtt.h afec0.h gmac.h tc0.h tc3.h tc1.h pwm0.h spi0.h uart0.h spi1.h xdmac.h supc.h rtc.h chipid.h uart4.h piod.h twihs1.h tc2.h ssc.h twihs0.h trng.h pwm1.h mcan1.h piob.h utmi.h acc.h uart2.h rstc.h twihs2.h usart1.h aes.h gpbr.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70n21.h same70n20.h same70q21.h same70n21b.h same70q20b.h same70q21b.h same70j20b.h same70q20.h same70j19.h same70j19b.h same70j21b.h same70n19.h same70q19b.h same70j21.h same70n19b.h same70j20.h same70n20b.h same70q19.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../../sam/utils/cmsis/same70/include/component/: sdramc.h twihs.h spi.h usart.h matrix.h rtc.h rstc.h efc.h pmc.h smc.h ssc.h pwm.h qspi.h wdt.h rswdt.h gpbr.h trng.h rtt.h utmi.h pio.h supc.h gmac.h hsmci.h acc.h usbhs.h aes.h dacc.h icm.h afec.h i2sc.h tc.h isi.h mcan.h chipid.h uart.h xdmac.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../../../sam/utils/fpu/: fpu.h
