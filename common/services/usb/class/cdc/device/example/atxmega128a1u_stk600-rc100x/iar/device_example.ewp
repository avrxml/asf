# IAR project device_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../xmega/boards/stk600/rc100x; ../../../../../../../../../xmega/utils; ../../../../../../../ioport; ../../../../../../../../../xmega/drivers/usart; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../../clock; ../../../../../../udc; ../../../../../..; ../../../../../../../../../xmega/boards; ../..; ../../../../../../../gpio; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../../boards; ..; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/class/cdc/device/example
    ../../: uart_xmega.c main.c ui.h conf_usb.h uart.h main.h
  group common/services/usb/class/cdc/device/example/atxmega128a1u_stk600-rc100x
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/cdc/device/example/atxmega128a1u_stk600-rc100x/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group xmega/boards/stk600/rc100x
    ../../../../../../../../../xmega/boards/stk600/rc100x/: init.c stk600_rc100x.h led.h
  group xmega/drivers/usart
    ../../../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/utils
    ../../../../../../../../../xmega/utils/: compiler.h assembler.h progmem.h status_codes.h
  group xmega/utils/preprocessor
    ../../../../../../../../../xmega/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../../../xmega/utils/assembler/: iar.h
