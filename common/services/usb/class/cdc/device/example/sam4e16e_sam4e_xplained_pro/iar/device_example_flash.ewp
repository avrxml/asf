# IAR project device_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_XPLAINED_PRO; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/boards/sam4e_xplained_pro; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/utils/fpu; ../../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/udp; ../../../../../../../../../sam/utils/cmsis/sam4e/include; ../..; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ..; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example_flash.bin
  ILINK.IlinkOutputFile: device_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e16e.h sam4e8c.h sam4e16c.h sam4e.h sam4e8e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4e/include/instance/: spi.h wdt.h pwm.h hsmci.h dmac.h twi1.h afec1.h pmc.h pioa.h rstc.h rtt.h can0.h uart1.h gmac.h chipid.h twi0.h efc.h rtc.h tc2.h aes.h supc.h dacc.h pioe.h usart1.h usart0.h matrix.h can1.h uart0.h acc.h pioc.h tc0.h gpbr.h rswdt.h smc.h piod.h cmcc.h piob.h udp.h afec0.h tc1.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4e/include/component/: dmac.h udp.h wdt.h tc.h gmac.h pmc.h matrix.h rtc.h pio.h efc.h acc.h spi.h rtt.h pdc.h rstc.h chipid.h uart.h afec.h can.h hsmci.h aes.h usart.h twi.h smc.h gpbr.h rswdt.h dacc.h cmcc.h supc.h pwm.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e8e.h sam4e8c.h sam4e16c.h sam4e16e.h
  group sam/utils/fpu
    ../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../../../../../sam/boards/sam4e_xplained_pro/: init.c sam4e_xplained_pro.h led.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/class/cdc/device/example
    ../../: uart_sam.c main.c uart.h ui.h conf_usb.h main.h
  group common/services/usb/class/cdc/device/example/sam4e16e_sam4e_xplained_pro
    ../: ui.c conf_sleepmgr.h conf_clock.h conf_board.h conf_example.h
  group common/services/usb/class/cdc/device/example/sam4e16e_sam4e_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam4e
    ../../../../../../../clock/sam4e/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
