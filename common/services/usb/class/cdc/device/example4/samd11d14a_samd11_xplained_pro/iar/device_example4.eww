<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_example4_flash.ewp</path>
	</project>
</workspace>
