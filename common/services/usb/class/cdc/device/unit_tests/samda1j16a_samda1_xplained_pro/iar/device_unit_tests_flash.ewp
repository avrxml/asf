# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAMDA1J16A__; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAMDA1_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; USART_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/interrupt; ../../..; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ..; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../../sam0/utils/cmsis/samda1/include; ../../../../../../../serial; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../..; ../../../../../../../../../sam0/boards/samda1_xplained_pro; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../../sam0/utils/cmsis/samda1/source; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/boards/samda1_xplained_pro
    ../../../../../../../../../sam0/boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../../../../sam0/utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../../../../sam0/utils/cmsis/samda1/include/: samda1j15b.h samda1j14a.h samda1g16a.h samda1.h samda1j16b.h samda1e15a.h samda1e16b.h samda1g14a.h samda1g16b.h samda1e14a.h samda1g15a.h samda1g14b.h samda1g15b.h samda1e14b.h samda1j16a.h samda1j15a.h samda1e16a.h samda1j14b.h samda1e15b.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samda1/include/pio/: samda1g15a.h samda1j15a.h samda1j16a.h samda1j14a.h samda1g15b.h samda1j16b.h samda1e15a.h samda1e16b.h samda1j14b.h samda1g14a.h samda1g16b.h samda1g14b.h samda1e14b.h samda1e15b.h samda1j15b.h samda1g16a.h samda1e14a.h samda1e16a.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samda1/include/instance/: adc.h tc4.h i2s.h sercom4.h evsys.h tcc2.h sercom2.h eic.h pac0.h pac2.h sercom0.h pm.h gclk.h usb.h ac.h pac1.h dac.h rtc.h tcc1.h tc3.h tcc0.h port.h mtb.h sysctrl.h tc6.h wdt.h tc5.h sercom1.h tc7.h sbmatrix.h sercom5.h nvmctrl.h dmac.h sercom3.h dsu.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../../../../sam0/utils/cmsis/samda1/include/component/: port.h pac.h adc.h dsu.h i2s.h gclk.h mtb.h hmatrixb.h pm.h wdt.h dmac.h tc.h sysctrl.h tcc.h evsys.h usb.h dac.h ac.h nvmctrl.h eic.h rtc.h sercom.h
  group sam0/utils/stdio
    ../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/class/cdc/device/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/cdc/device/unit_tests/samda1j16a_samda1_xplained_pro
    ../: conf_board.h conf_sleepmgr.h conf_test.h conf_clocks.h conf_extint.h
  group common/services/usb/class/cdc/device/unit_tests/samda1j16a_samda1_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
