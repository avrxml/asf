# IAR project device_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; UDD_ENABLE; BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../serial; ../../../../../../../../../avr32/boards/evk1105; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../../clock; ../..; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../serial/uc3_usart; ..; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/class/cdc/device/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/cdc/device/unit_tests/at32uc3a0512_evk1105
    ../: conf_test.h conf_sleepmgr.h conf_clock.h conf_board.h conf_usart_serial.h
  group common/services/usb/class/cdc/device/unit_tests/at32uc3a0512_evk1105/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/uc3a0_a1
    ../../../../../../../clock/uc3a0_a1/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../serial/uc3_usart/: usart_serial.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_otg.h usbb_device.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/evk1105
    ../../../../../../../../../avr32/boards/evk1105/: led.c init.c led.h evk1105.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
