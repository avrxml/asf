<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_example2.ewp</path>
	</project>
</workspace>
