# IAR project host_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/flexcom; ../../../../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../../../../sam/drivers/efc; ../../../../../../../../../sam/utils/fpu; ../../..; ../../../../../../../../../sam/drivers/uhp; ../../../../../../../../../sam/drivers/supc; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam/utils/cmsis/samg/samg55/include; ../../../..; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../sam/drivers/matrix; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/utils/preprocessor; ../../../../../..; ../../../../../../../delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../..; ../../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example_flash.bin
  ILINK.IlinkOutputFile: host_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x800
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55g19.h samg55.h samg55j19.h system_samg55.h samg55j18.h samg55n19.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: tc0.h usart1.h chipid.h matrix.h wdt.h twi4.h twi2.h pdmic1.h twi6.h i2sc1.h twi0.h crccu.h efc.h flexcom6.h flexcom4.h twi5.h twi3.h spi2.h rtt.h gpbr.h pdmic0.h i2sc0.h pmc.h twi1.h supc.h usart7.h flexcom2.h flexcom1.h flexcom0.h piob.h flexcom7.h twi7.h flexcom5.h usart5.h spi4.h spi3.h adc.h cmcc.h spi6.h spi0.h uhp.h rtc.h usart3.h tc1.h usart0.h udp.h usart6.h flexcom3.h pioa.h usart4.h spi5.h spi7.h spi1.h usart2.h mem2mem.h rstc.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: pmc.h matrix.h adc.h gpbr.h uhp.h twi.h mem2mem.h cmcc.h pdc.h wdt.h chipid.h flexcom.h supc.h i2sc.h tc.h efc.h pio.h usart.h spi.h rtt.h rstc.h udp.h pdmic.h crccu.h rtc.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g18.h samg55n19.h samg55j18.h samg55j19.h samg55g19.h
  group sam/utils/fpu
    ../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/flexcom
    ../../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/matrix
    ../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/supc
    ../../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/uhp
    ../../../../../../../../../sam/drivers/uhp/: uhp_host.c
  group sam/drivers/uhp/ohci
    ../../../../../../../../../sam/drivers/uhp/ohci/: ohci_hcd.c ohci.h ohci_hcd.h
  group sam/drivers/efc
    ../../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../../../../sam/boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/host
    ../../../: uhi_cdc.c uhi_cdc.h
  group common/services/usb/class/cdc/host/example
    ../../: uart_sam.c main.c uart.h conf_usb_host.h main.h ui.h
  group common/services/usb/class/cdc/host/example/samg55j19_samg_xplained_pro
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/usb/class/cdc/host/example/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/samg
    ../../../../../../../clock/samg/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
