# IAR project host_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/drivers/uotghs; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/boards/sam3x_ek; ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../..; ../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../..; ..; ../../../../../../../gpio; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: UHD_ENABLE; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example_flash.bin
  ILINK.IlinkOutputFile: host_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uotghs
    ../../../../../../../../../sam/drivers/uotghs/: uotghs_host.c uotghs_otg.h uotghs_host.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c system_sam3x.h exceptions.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../../../../sam/utils/cmsis/sam3x/include/: sam3a4c.h sam3x8e.h sam3a8c.h sam3x8h.h sam3x8c.h sam3xa.h sam3x4e.h sam3x4c.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_trng.h instance_pwm.h instance_tc0.h instance_piof.h instance_efc1.h instance_uart.h instance_matrix.h instance_dacc.h instance_pmc.h instance_usart1.h instance_rstc.h instance_tc1.h instance_hsmci.h instance_usart3.h instance_efc0.h instance_can0.h instance_chipid.h instance_tc2.h instance_spi0.h instance_adc.h instance_spi1.h instance_twi1.h instance_gpbr.h instance_pioe.h instance_supc.h instance_emac.h instance_ssc.h instance_rtt.h instance_uotghs.h instance_dmac.h instance_twi0.h instance_pioc.h instance_pioa.h instance_sdramc.h instance_piob.h instance_rtc.h instance_usart0.h instance_smc.h instance_wdt.h instance_can1.h instance_usart2.h instance_piod.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../../../../sam/utils/cmsis/sam3x/include/component/: component_rtc.h component_uart.h component_ssc.h component_rtt.h component_usart.h component_trng.h component_supc.h component_matrix.h component_spi.h component_adc.h component_rstc.h component_uotghs.h component_sdramc.h component_smc.h component_chipid.h component_pdc.h component_dmac.h component_dacc.h component_pwm.h component_twi.h component_pmc.h component_wdt.h component_hsmci.h component_gpbr.h component_can.h component_efc.h component_emac.h component_tc.h component_pio.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3x8e.h pio_sam3x8c.h pio_sam3x8h.h pio_sam3a8c.h pio_sam3x4c.h pio_sam3a4c.h pio_sam3x4e.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/boards/sam3x_ek
    ../../../../../../../../../sam/boards/sam3x_ek/: init.c led.c sam3x_ek.h led.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/host
    ../../../: uhi_cdc.c uhi_cdc.h
  group common/services/usb/class/cdc/host/example
    ../../: uart_sam.c main.c uart.h conf_usb_host.h main.h ui.h
  group common/services/usb/class/cdc/host/example/sam3x8h_sam3x_ek
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/usb/class/cdc/host/example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../../../clock/sam3x/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
