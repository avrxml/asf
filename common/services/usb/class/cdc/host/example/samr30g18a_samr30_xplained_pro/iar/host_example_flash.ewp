# IAR project host_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; BOARD=SAMR30_XPLAINED_PRO; EXTINT_CALLBACK_MODE=true; UHD_ENABLE; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; USB_HOST_LPM_SUPPORT
  ICCARM.CCIncludePath2: ..; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/sercom/usart; ../../..; ../../../../../../../../../sam0/utils/cmsis/samr30/source; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/boards/samr30_xplained_pro; ../../../..; ../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../uhc; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../..; ../../../../../../../../../sam0/utils/cmsis/samr30/include; ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/drivers/system/clock/clock_samr30; ../..; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example_flash.bin
  ILINK.IlinkOutputFile: host_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x800
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/host
    ../../../: uhi_cdc.c uhi_cdc.h
  group common/services/usb/class/cdc/host/example
    ../../: uart_samd.c main.c uart.h conf_usb_host.h main.h ui.h
  group common/services/usb/class/cdc/host/example/samr30g18a_samr30_xplained_pro
    ../: ui.c conf_example.h conf_clocks.h conf_board.h conf_sleepmgr.h conf_extint.h
  group common/services/usb/class/cdc/host/example/samr30g18a_samr30_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/: samr30.h samr30g18a.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/component/: mclk.h nvmctrl.h oscctrl.h sercom.h tc.h port.h tcc.h ac.h supc.h rtc.h rstc.h gclk.h usb.h dmac.h mtb.h dsu.h wdt.h adc.h osc32kctrl.h ccl.h pm.h eic.h tal.h pac.h rfctrl.h evsys.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30e18a.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samr30/include/instance/: tc4.h adc.h sercom0.h ccl.h sercom2.h evsys.h rstc.h osc32kctrl.h nvmctrl.h gclk.h sercom4.h pac.h tal.h sercom1.h sercom3.h port.h oscctrl.h tc0.h rfctrl.h dmac.h sercom5.h dsu.h tc1.h pm.h mtb.h mclk.h supc.h tcc1.h usb.h ac.h wdt.h eic.h tcc0.h rtc.h tcc2.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../../../../sam0/drivers/system/clock/clock_samr30/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
