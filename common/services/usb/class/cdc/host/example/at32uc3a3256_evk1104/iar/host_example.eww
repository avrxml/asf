<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\host_example.ewp</path>
	</project>
</workspace>
