<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_freertos_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\example_freertos_sram.ewp</path>
	</project>
</workspace>
