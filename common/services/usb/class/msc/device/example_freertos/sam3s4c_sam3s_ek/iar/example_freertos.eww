<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_freertos_flash.ewp</path>
	</project>
</workspace>
