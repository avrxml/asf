# IAR project example_freertos_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREERTOS_USED; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ..; ../..; ../../../../../../../sleepmgr; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pio; ../../../..; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/pdc; ../../../../../../../../utils; ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/drivers/matrix; ../../../../../../../../components/memory/nand_flash/nand_flash_ebi; ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/boards/sam4s_ek2; ../../../../../../../../../sam/drivers/udp; ../../../../../../../gpio; ../../../../../../../storage/ecc_hamming; ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../delay; ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/hsmci; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_freertos_flash.bin
  ILINK.IlinkOutputFile: example_freertos_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x4000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/: nand_flash_spare_scheme.c nand_flash_raw_smc.c nand_flash_ecc_sw.c nand_flash_model.c nand_flash_model.h nand_flash_raw.h nand_flash_common.h nand_flash_ecc.h nand_flash_spare_scheme.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c nand_flash_translation.h nand_flash_management.h nand_flash_mem.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm4.a
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_protocol.h sd_mmc_mem.h sd_mmc.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: spc_protocol.h usb_protocol_msc.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/example_freertos
    ../../: memories_initialization_sam.c exceptions_sam.c main.c conf_usb.h main.h ui.h
  group common/services/usb/class/msc/device/example_freertos/sam4sd32c_sam4s_ek2
    ../: ui.c conf_clock.h conf_board.h conf_sd_mmc.h conf_sleepmgr.h conf_access.h FreeRTOSConfig.h conf_nf.h
  group common/services/usb/class/msc/device/example_freertos/sam4sd32c_sam4s_ek2/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udc.h udd.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/storage/ecc_hamming
    ../../../../../../../storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c exceptions.h system_sam4s.h
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4sa16b.h sam4s.h sam4sa16c.h sam4sd32b.h sam4s8c.h sam4sd16b.h sam4sd32c.h sam4s8b.h sam4s16b.h sam4sd16c.h sam4s16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_uart1.h instance_supc.h instance_efc1.h instance_dacc.h instance_acc.h instance_pmc.h instance_chipid.h instance_rstc.h instance_twi0.h instance_matrix.h instance_uart0.h instance_efc0.h instance_pioa.h instance_udp.h instance_hsmci.h instance_gpbr.h instance_pioc.h instance_rtc.h instance_piob.h instance_tc0.h instance_crccu.h instance_ssc.h instance_usart0.h instance_adc.h instance_usart1.h instance_spi.h instance_wdt.h instance_smc.h instance_twi1.h instance_tc1.h instance_cmcc.h instance_pwm.h instance_rtt.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_acc.h component_hsmci.h component_ssc.h component_pmc.h component_cmcc.h component_adc.h component_tc.h component_supc.h component_uart.h component_crccu.h component_chipid.h component_rstc.h component_twi.h component_pwm.h component_pdc.h component_usart.h component_pio.h component_dacc.h component_wdt.h component_gpbr.h component_rtt.h component_udp.h component_matrix.h component_spi.h component_smc.h component_rtc.h component_efc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4sd16c.h pio_sam4s16b.h pio_sam4sa16c.h pio_sam4sd32b.h pio_sam4s16c.h pio_sam4sa16b.h pio_sam4s8c.h pio_sam4sd32c.h pio_sam4sd16b.h pio_sam4s8b.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/hsmci
    ../../../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/pdc
    ../../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/matrix
    ../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/boards/sam4s_ek2
    ../../../../../../../../../sam/boards/sam4s_ek2/: led.c init.c sam4s_ek2.h led.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: list.c queue.c croutine.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: mpu_wrappers.h task.h list.h semphr.h croutine.h queue.h timers.h StackMacros.h projdefs.h FreeRTOS.h portable.h
