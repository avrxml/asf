# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3U4E__; ARM_MATH_CM3=true; VIRTUAL_MEMORY_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../..; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../serial; ../../../../../../../sleepmgr; ../../../../../../../../utils; ..; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../../sam/drivers/dmac; ../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../..; ../..; ../../../../../../../gpio; ../../../../../../../delay; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../udc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/hsmci; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c unit_tests.h conf_usb.h
  group common/services/usb/class/msc/device/unit_tests/sam3u4e_sam3u_ek
    ../: conf_virtual_mem.h conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_sleepmgr.h conf_test.h conf_access.h
  group common/services/usb/class/msc/device/unit_tests/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam3u
    ../../../../../../../clock/sam3u/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_protocol.h sd_mmc_mem.h sd_mmc.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/udphs
    ../../../../../../../../../sam/drivers/udphs/: udphs_device.c udphs_device.h
  group sam/drivers/hsmci
    ../../../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/dmac
    ../../../../../../../../../sam/drivers/dmac/: dmac.c dmac.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c exceptions.h system_sam3u.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../../../../sam/utils/cmsis/sam3u/include/: sam3u1c.h sam3u.h sam3u1e.h sam3u4e.h sam3u2c.h sam3u4c.h sam3u2e.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../../../../sam/utils/cmsis/sam3u/include/component/: component_rtc.h component_adc.h component_hsmci.h component_adc12b.h component_gpbr.h component_ssc.h component_tc.h component_supc.h component_rtt.h component_uart.h component_efc.h component_dmac.h component_pio.h component_chipid.h component_wdt.h component_smc.h component_pdc.h component_twi.h component_pwm.h component_udphs.h component_usart.h component_pmc.h component_spi.h component_matrix.h component_rstc.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_dmac.h instance_hsmci.h instance_usart2.h instance_rstc.h instance_twi0.h instance_tc0.h instance_usart0.h instance_spi.h instance_pioc.h instance_matrix.h instance_pioa.h instance_smc.h instance_adc12b.h instance_twi1.h instance_udphs.h instance_wdt.h instance_efc0.h instance_pwm.h instance_adc.h instance_pmc.h instance_uart.h instance_chipid.h instance_rtc.h instance_usart3.h instance_supc.h instance_usart1.h instance_efc1.h instance_ssc.h instance_piob.h instance_rtt.h instance_gpbr.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2c.h pio_sam3u4c.h pio_sam3u4e.h pio_sam3u1c.h pio_sam3u1e.h pio_sam3u2e.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3u_ek
    ../../../../../../../../../sam/boards/sam3u_ek/: init.c led.c led.h sam3u_ek.h
