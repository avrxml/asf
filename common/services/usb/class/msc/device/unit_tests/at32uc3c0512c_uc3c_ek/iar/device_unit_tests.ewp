# IAR project device_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK; _ASSERT_ENABLE_; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../avr32/boards; ../../../../../../../spi/uc3_spi; ../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../serial; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../..; ../../../../../../../clock; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../..; ../../../../../../../delay; ../../../../../../../../../avr32/boards/uc3c_ek; ../../../../../../../serial/uc3_usart; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../ioport; ../../../..; ../../../../../../../../../avr32/utils/preprocessor; ..; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3c
    ../../../../../../../clock/uc3c/: pll.c sysclk.c osc.c genclk.h pll.h sysclk.h osc.h
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/unit_tests
    ../../: memories_initialization_uc3.c unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/msc/device/unit_tests/at32uc3c0512c_uc3c_ek
    ../: conf_at45dbx.h conf_access.h conf_virtual_mem.h conf_test.h conf_board.h conf_sleepmgr.h conf_sd_mmc.h conf_usart_serial.h conf_clock.h conf_spi_master.h
  group common/services/usb/class/msc/device/unit_tests/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../serial/uc3_usart/: usart_serial.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../../ioport/uc3/: ioport.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx_hal_spi.h at45dbx.h at45dbx_mem.h
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc_mem.h sd_mmc.h sd_mmc_protocol.h sd_mmc_spi.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group avr32/boards/uc3c_ek
    ../../../../../../../../../avr32/boards/uc3c_ek/: init.c led.c led.h uc3c_ek.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c pm_uc3c.h sleep.h power_clocks_lib.h
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/usbc
    ../../../../../../../../../avr32/drivers/usbc/: usbc_device.c usbc_device.h usbc_otg.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
