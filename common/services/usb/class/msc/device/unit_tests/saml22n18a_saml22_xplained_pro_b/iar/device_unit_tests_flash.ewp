# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO_B; _ASSERT_ENABLE_; USART_CALLBACK_MODE=true; ACCESS_USB_ENABLED; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; VIRTUAL_MEMORY_ENABLE; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../sam0/utils/cmsis/saml22/include; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../serial; ../../../../../../../../../sam0/utils/cmsis/saml22/source; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../..; ../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam0/boards/saml22_xplained_pro_b; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22; ../..; ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/boards; ..; ../../../../../../../../../sam0/drivers/system/clock/clock_saml22; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ../../../..; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../storage/ctrl_access; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_samd.c unit_tests.h conf_usb.h
  group common/services/usb/class/msc/device/unit_tests/saml22n18a_saml22_xplained_pro_b
    ../: conf_virtual_mem.h conf_board.h conf_sleepmgr.h conf_test.h conf_access.h conf_clocks.h conf_extint.h
  group common/services/usb/class/msc/device/unit_tests/saml22n18a_saml22_xplained_pro_b/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../../../../sam0/drivers/system/clock/clock_saml22/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../../../../sam0/utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../../../../sam0/utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../../../../sam0/utils/cmsis/saml22/include/: saml22n16a.h saml22n17a.h saml22g18a.h saml22j16a.h saml22n18a.h saml22g17a.h saml22j18a.h saml22g16a.h saml22.h saml22j17a.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../../../../sam0/utils/cmsis/saml22/include/instance/: gclk.h rstc.h slcd.h aes.h eic.h dmac.h pac.h supc.h usb.h tc0.h sercom3.h tc3.h tc1.h tal.h wdt.h port.h freqm.h evsys.h mclk.h sercom5.h sercom2.h oscctrl.h tc2.h sercom1.h ccl.h mtb.h dsu.h osc32kctrl.h nvmctrl.h sercom4.h rtc.h adc.h sercom0.h trng.h tcc0.h ac.h pm.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../../../../sam0/utils/cmsis/saml22/include/component/: ccl.h tal.h tc.h wdt.h sercom.h rstc.h supc.h usb.h eic.h evsys.h osc32kctrl.h oscctrl.h nvmctrl.h mtb.h pm.h gclk.h ac.h rtc.h tcc.h pac.h trng.h slcd.h dmac.h port.h adc.h dsu.h aes.h mclk.h freqm.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../../../../sam0/utils/cmsis/saml22/include/pio/: saml22n17a.h saml22j16a.h saml22g16a.h saml22g18a.h saml22j18a.h saml22j17a.h saml22n18a.h saml22g17a.h saml22n16a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../../../../sam0/boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
