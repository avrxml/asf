# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; UDD_ENABLE; ARM_MATH_CM7=true; BOARD=SAME70_XPLAINED; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; __SAME70Q21B__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/utils/cmsis/same70/include; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam/utils/fpu; ../../../../../../../serial; ..; ../../../../../../../../../sam/drivers/mpu; ../../../../../../../sleepmgr; ../..; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/usbhs; ../../../../../../../../utils; ../../../../../../../gpio; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/boards/same70_xplained; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../boards; ../../../../../../../ioport; ../../../..; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../../sam/utils/cmsis/same70/include/: same70.h same70n20b.h same70q19b.h same70n20.h same70n19b.h same70q20b.h same70j19.h same70j21b.h same70q21b.h same70q20.h same70n21b.h same70j21.h same70j19b.h same70n19.h same70q19.h same70j20b.h same70q21.h same70j20.h same70n21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../../sam/utils/cmsis/same70/include/instance/: pioe.h hsmci.h mcan0.h i2sc1.h pioc.h pmc.h pioa.h afec1.h rswdt.h usbhs.h usart2.h uart3.h efc.h icm.h uart1.h matrix.h usart0.h isi.h qspi.h sdramc.h wdt.h i2sc0.h dacc.h smc.h rtt.h afec0.h gmac.h tc0.h tc3.h tc1.h pwm0.h spi0.h uart0.h spi1.h xdmac.h supc.h rtc.h chipid.h uart4.h piod.h twihs1.h tc2.h ssc.h trng.h pwm1.h mcan1.h piob.h utmi.h acc.h uart2.h rstc.h twihs2.h twihs0.h usart1.h aes.h gpbr.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../../sam/utils/cmsis/same70/include/component/: sdramc.h twihs.h spi.h usart.h matrix.h rtc.h rstc.h efc.h pmc.h smc.h ssc.h pwm.h qspi.h wdt.h rswdt.h gpbr.h trng.h rtt.h utmi.h pio.h supc.h hsmci.h acc.h usbhs.h aes.h dacc.h icm.h gmac.h afec.h i2sc.h tc.h isi.h mcan.h chipid.h uart.h xdmac.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70n20.h same70q21.h same70n21b.h same70q20b.h same70n20b.h same70q21b.h same70n21.h same70j20b.h same70q20.h same70j19.h same70j19b.h same70j21b.h same70j21.h same70n19.h same70q19b.h same70n19b.h same70j20.h same70q19.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/drivers/mpu
    ../../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usbhs
    ../../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/boards/same70_xplained
    ../../../../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc_conf.h udi_msc.h
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c unit_tests.h conf_usb.h
  group common/services/usb/class/msc/device/unit_tests/same70q21_same70_xplained
    ../: conf_virtual_mem.h conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h conf_access.h
  group common/services/usb/class/msc/device/unit_tests/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/same70
    ../../../../../../../clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
