# IAR project device_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT; BOARD=STK600_RC100X; AT45DBX_ENABLE
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../xmega/boards/stk600/rc100x; ../../../../../../../../../xmega/drivers/pmic; ../../../../../../../spi/xmega_spi; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../xmega/utils; ../../../..; ..; ../../../../../../../serial; ../../../../../../../ioport; ../../../../../../../serial/xmega_usart; ../../../../../../../../../xmega/drivers/usart; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../clock; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../xmega/boards; ../..; ../../../../../../../gpio; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; ../../../../../../../storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; ACCESS_USB_ENABLED; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT; BOARD=STK600_RC100X; AT45DBX_ENABLE
  group xmega/boards/stk600/rc100x
    ../../../../../../../../../xmega/boards/stk600/rc100x/: init.c stk600_rc100x.h led.h
  group xmega/drivers/usart
    ../../../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/spi
    ../../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/utils
    ../../../../../../../../../xmega/utils/: compiler.h assembler.h progmem.h status_codes.h
  group xmega/utils/preprocessor
    ../../../../../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/bit_handling
    ../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../../../xmega/utils/assembler/: iar.h
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/usb/class/msc
    ../../../../: sbc_protocol.h usb_protocol_msc.h spc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_xmega.c unit_tests.h conf_usb.h
  group common/services/usb/class/msc/device/unit_tests/atxmega128a1u_stk600-rc100x
    ../: conf_test.h conf_clock.h conf_sleepmgr.h conf_board.h conf_access.h conf_usart_serial.h conf_at45dbx.h conf_spi_master.h
  group common/services/usb/class/msc/device/unit_tests/atxmega128a1u_stk600-rc100x/iar
    ./: asf.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/spi
    ../../../../../../../spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../../serial/xmega_usart/: usart_serial.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx_mem.c at45dbx.c at45dbx_hal_spi.h at45dbx.h at45dbx_mem.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../boards/: board.h
