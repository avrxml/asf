# IAR project device_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; BOARD=EVK1101; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../..; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../avr32/boards; ../../../..; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ..; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/boards/evk1101; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../..; ../../../../../../../clock; ../../../../../../udc; ../../../../../..; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../delay; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../ioport; ../../../../../../../spi/uc3_spi; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc_conf.h udi_msc.h
  group common/services/usb/class/msc/device/example
    ../../: memories_initialization_uc3.c main.c ui.h conf_usb.h main.h
  group common/services/usb/class/msc/device/example/at32uc3b0256_evk1101
    ../: ui.c conf_at45dbx.h conf_access.h conf_spi_master.h conf_clock.h conf_board.h conf_sleepmgr.h conf_sd_mmc.h
  group common/services/usb/class/msc/device/example/at32uc3b0256_evk1101/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc.h udc_desc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3b0_b1
    ../../../../../../../clock/uc3b0_b1/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../../ioport/uc3/: ioport.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx_hal_spi.h at45dbx.h at45dbx_mem.h
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc_mem.h sd_mmc.h sd_mmc_protocol.h sd_mmc_spi.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_otg.h usbb_device.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1101
    ../../../../../../../../../avr32/boards/evk1101/: init.c led.c led.h evk1101.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
