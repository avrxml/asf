# IAR project device_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3S_EK2; __SAM3SD8C__; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; ARM_MATH_CM3=true; VIRTUAL_MEMORY_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../../../../../../../sleepmgr; ..; ../..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pio; ../../../..; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/pdc; ../../../../../../../../utils; ../../..; ../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../../../../sam/drivers/matrix; ../../../../../../../../components/memory/nand_flash/nand_flash_ebi; ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/udp; ../../../../../../../../../sam/boards/sam3s_ek2; ../../../../../../../gpio; ../../../../../../../storage/ecc_hamming; ../../../../../../../delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/hsmci; ../../../../../../../../../sam/utils/cmsis/sam3s8/include; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example_flash.bin
  ILINK.IlinkOutputFile: device_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=16K
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/: nand_flash_spare_scheme.c nand_flash_raw_smc.c nand_flash_model.c nand_flash_ecc_sw.c nand_flash_model.h nand_flash_raw.h nand_flash_common.h nand_flash_ecc.h nand_flash_spare_scheme.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c nand_flash_management.h nand_flash_translation.h nand_flash_mem.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm3.a
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_protocol.h sd_mmc_mem.h sd_mmc.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/example
    ../../: memories_initialization_sam.c main.c conf_usb.h main.h ui.h
  group common/services/usb/class/msc/device/example/sam3sd8c_sam3s_ek2
    ../: ui.c conf_virtual_mem.h conf_clock.h conf_board.h conf_sd_mmc.h conf_sleepmgr.h conf_access.h conf_nf.h
  group common/services/usb/class/msc/device/example/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/storage/ecc_hamming
    ../../../../../../../storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam3s
    ../../../../../../../clock/sam3s/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c system_sam3sd8.h exceptions.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/: sam3sd8c.h sam3sd8b.h sam3s8c.h sam3s8.h sam3s8b.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_efc.h component_acc.h component_supc.h component_wdt.h component_tc.h component_rstc.h component_pdc.h component_dacc.h component_udp.h component_hsmci.h component_matrix.h component_adc.h component_usart.h component_gpbr.h component_crccu.h component_pio.h component_rtc.h component_chipid.h component_pmc.h component_spi.h component_twi.h component_pwm.h component_rtt.h component_uart.h component_smc.h component_ssc.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_adc.h instance_twi1.h instance_usart1.h instance_pioc.h instance_twi0.h instance_tc1.h instance_udp.h instance_ssc.h instance_rtt.h instance_rstc.h instance_supc.h instance_pioa.h instance_crccu.h instance_usart0.h instance_pwm.h instance_usart2.h instance_chipid.h instance_efc.h instance_uart1.h instance_gpbr.h instance_acc.h instance_tc0.h instance_hsmci.h instance_pmc.h instance_smc.h instance_wdt.h instance_uart0.h instance_matrix.h instance_piob.h instance_rtc.h instance_dacc.h instance_spi.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3s8b.h pio_sam3sd8c.h pio_sam3s8c.h pio_sam3sd8b.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/hsmci
    ../../../../../../../../../sam/drivers/hsmci/: hsmci.c hsmci.h
  group sam/drivers/pdc
    ../../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/matrix
    ../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/boards/sam3s_ek2
    ../../../../../../../../../sam/boards/sam3s_ek2/: led.c init.c sam3s_ek2.h led.h
