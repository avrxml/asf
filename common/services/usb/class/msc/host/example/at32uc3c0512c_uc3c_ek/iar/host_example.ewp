# IAR project host_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=UC3C_EK; ACCESS_MEM_TO_RAM_ENABLED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../avr32/services/fs/fat; ../../../../../../../../../avr32/boards; ../../../..; ../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../avr32/drivers/pm; ../..; ../../../../../../../../../avr32/drivers/eic; ..; ../../../../../../../../../avr32/boards/uc3c_ek; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../uhc; ../../../../../../../clock; ../../../../../..; ../../..; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=UC3C_EK; ACCESS_MEM_TO_RAM_ENABLED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3c
    ../../../../../../../clock/uc3c/: pll.c sysclk.c osc.c pll.h sysclk.h genclk.h osc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/host
    ../../../: uhi_msc_mem.c uhi_msc.c uhi_msc.h uhi_msc_mem.h
  group common/services/usb/class/msc/host/example
    ../../: main.c conf_access.h conf_explorer.h ui.h conf_usb_host.h main.h
  group common/services/usb/class/msc/host/example/at32uc3c0512c_uc3c_ek
    ../: ui.c conf_sleepmgr.h conf_clock.h conf_board.h
  group common/services/usb/class/msc/host/example/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhc.h uhd.h uhi.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group avr32/services/fs/fat
    ../../../../../../../../../avr32/services/fs/fat/: navigation.c fat_unusual.c file.c fat.c navigation.h file.h fat.h fs_com.h
  group avr32/drivers/eic
    ../../../../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c pm_uc3c.h sleep.h power_clocks_lib.h
  group avr32/drivers/usbc
    ../../../../../../../../../avr32/drivers/usbc/: usbc_host.c usbc_host.h usbc_otg.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/boards/uc3c_ek
    ../../../../../../../../../avr32/boards/uc3c_ek/: init.c led.c led.h uc3c_ek.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
