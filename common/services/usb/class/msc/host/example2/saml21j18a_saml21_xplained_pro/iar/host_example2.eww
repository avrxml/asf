<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\host_example2_flash.ewp</path>
	</project>
</workspace>
