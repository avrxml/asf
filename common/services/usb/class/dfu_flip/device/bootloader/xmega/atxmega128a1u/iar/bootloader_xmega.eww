<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bootloader_xmega.ewp</path>
	</project>
</workspace>
