# IAR project xmega_small.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm64a3u ATxmega64A3U
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../../xmega/drivers/usb; ../../../../../../../../clock; .; ../../../../../../../../../../xmega/drivers/nvm; ../..; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../boards; ../../../../../../../../../../xmega/utils; ../../../../../../../udc; ../../../../../../..; ../../conf; ../../../../../../../../../../xmega/boards/dummy; ../../../..; ../../../../../../../../isp/flip; ../../../../../../../../../../xmega/boards; ../../../../../../../../../utils; ../../../../../../../../../../xmega/drivers/cpu; ../../../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  XLINK.XclFile: atxmega64a3u_boot.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc_dfu_small.c udc.h udi.h udd.h udc_desc.h
  group common/services/usb/class/dfu_flip
    ../../../../../: usb_protocol_dfu.h
  group common/services/usb/class/dfu_flip/device
    ../../../../: udi_dfu_atmel_desc.c udi_dfu_atmel.c udi_dfu_atmel.h udi_dfu_atmel_conf.h
  group common/services/usb/class/dfu_flip/device/bootloader/xmega
    ../../: sysclk_opt.c main.c main.h
  group common/services/usb/class/dfu_flip/device/bootloader/xmega/conf
    ../../conf/: conf_usb.h conf_clock.h conf_isp.h conf_board.h
  group common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega64a3u/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../../clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/isp/flip
    ../../../../../../../../isp/flip/: flip_protocol.h isp.h
  group common/services/isp/flip/xmega
    ../../../../../../../../isp/flip/xmega/: isp.c cstartup.s90
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/boards/dummy
    ../../../../../../../../../../xmega/boards/dummy/: dummy_board.h
  group xmega/utils
    ../../../../../../../../../../xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/bit_handling
    ../../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../../../../../xmega/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group xmega/utils/assembler
    ../../../../../../../../../../xmega/utils/assembler/: iar.h
