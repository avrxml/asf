# IAR project bootloader_avr32.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=DUMMY_BOARD; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../intc; ../../../../../../../../../../avr32/boards/dummy; ../../../../../../../../../../avr32/drivers/scif; ../../../..; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../../avr32/drivers/pm; ../../../../..; ../../conf; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../avr32/drivers/ast; ../../../../../../../../../../avr32/utils; ../../../../../../../../../utils; ../../../../../../../../../../avr32/services/freq_detect; ../../../../../../../../clock; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../../isp/flip/uc3; .; ../../../../../../../../../boards; ../..; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../isp/flip; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=DUMMY_BOARD; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkat32uc3c-isp.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c pm_uc3c.h sleep.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/scif
    ../../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/usbc
    ../../../../../../../../../../avr32/drivers/usbc/: usbc_device.c usbc_device.h usbc_otg.h
  group avr32/drivers/ast
    ../../../../../../../../../../avr32/drivers/ast/: ast.c ast.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/services/freq_detect
    ../../../../../../../../../../avr32/services/freq_detect/: freq_detect.c freq_detect.h
  group avr32/utils
    ../../../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/preprocessor
    ../../../../../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/dummy
    ../../../../../../../../../../avr32/boards/dummy/: dummy_board.h
  group common/services/clock
    ../../../../../../../../clock/: pll.h sysclk.h genclk.h osc.h
  group common/services/clock/uc3c
    ../../../../../../../../clock/uc3c/: sysclk.c pll.c osc.c pll.h sysclk.h genclk.h osc.h
  group common/services/isp/flip
    ../../../../../../../../isp/flip/: flip_protocol.h isp.h
  group common/services/isp/flip/uc3
    ../../../../../../../../isp/flip/uc3/: isp.c boot.s82 flash_api.h boot.h
  group common/services/usb
    ../../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/services/usb/class/dfu_flip
    ../../../../../: usb_protocol_dfu.h
  group common/services/usb/class/dfu_flip/device
    ../../../../: udi_dfu_atmel_desc.c udi_dfu_atmel.c udi_dfu_atmel.h udi_dfu_atmel_conf.h
  group common/services/usb/class/dfu_flip/device/bootloader/avr32
    ../../: main.c sysclk_auto.h main.h
  group common/services/usb/class/dfu_flip/device/bootloader/avr32/intc
    ../../intc/: intc.c intc.h
  group common/services/usb/class/dfu_flip/device/bootloader/avr32/at32uc3c
    ../: sysclk_auto.c
  group common/services/usb/class/dfu_flip/device/bootloader/avr32/at32uc3c/iar
    ./: asf.h
  group common/services/usb/class/dfu_flip/device/bootloader/avr32/conf
    ../../conf/: conf_freq_detect.h conf_usb.h conf_clock.h conf_isp.h conf_board.h
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../boards/: board.h
