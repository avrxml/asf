# IAR project host_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1104; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../..; ../../../../../../../../../avr32/drivers/rtc; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/eic; ../../../../../../../../../avr32/components/touch/qt60168; ../../../../../../../../../avr32/components/display/et024006dhu; ../..; ../../../../../../../../../avr32/utils/debug; ../../../../../../../../../avr32/drivers/tc; ../../../../../../../../../avr32/drivers/adc; ../../../../../../../../../avr32/boards/evk1104; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../../../../../uhc; ../../../../../../../clock; ..; ../../../../../..; ../../../../../../../delay; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../..; ../../../../../../../../../avr32/drivers/ebi/smc; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1104; CONFIG_INTERRUPT_FORCE_INTC
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/aoa
    ../../../../: usb_protocol_aoa.h
  group common/services/usb/class/aoa/host
    ../../../: uhi_aoa.c uhi_aoa.h
  group common/services/usb/class/aoa/host/example
    ../../: main.c ui.h conf_usb_host.h main.h
  group common/services/usb/class/aoa/host/example/at32uc3a3256_evk1104
    ../: cellphone.c usb_connector.c ui.c conf_qt60168.h cellphone.h usb_connector.h conf_clock.h conf_board.h conf_aoa.h conf_sleepmgr.h conf_ebi.h conf_et024006dhu.h
  group common/services/usb/class/aoa/host/example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../clock/uc3a3_a4/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../../../../avr32/utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/boards/evk1104
    ../../../../../../../../../avr32/boards/evk1104/: led.c init.c led.h evk1104.h
  group avr32/drivers/eic
    ../../../../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c pm.h sleep.h power_clocks_lib.h
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_host.c usbb_otg.h usbb_host.h
  group avr32/drivers/ebi/smc
    ../../../../../../../../../avr32/drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/adc
    ../../../../../../../../../avr32/drivers/adc/: adc.c adc.h
  group avr32/drivers/tc
    ../../../../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/intc
    ../../../../../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/rtc
    ../../../../../../../../../avr32/drivers/rtc/: rtc.c rtc.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/components/touch/qt60168
    ../../../../../../../../../avr32/components/touch/qt60168/: qt60168.c qt60168.h
  group avr32/components/display/et024006dhu
    ../../../../../../../../../avr32/components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
