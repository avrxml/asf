<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\host_example_flash.ewp</path>
	</project>
</workspace>
