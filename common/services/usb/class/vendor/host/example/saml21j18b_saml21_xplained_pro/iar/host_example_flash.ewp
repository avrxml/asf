# IAR project host_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EXTINT_CALLBACK_MODE=true; UHD_ENABLE; ARM_MATH_CM0PLUS=true; USB_HOST_LPM_SUPPORT; __SAML21J18B__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../../../../sam0/boards/saml21_xplained_pro_b; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../..; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/utils/cmsis/saml21/include_b; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../uhc; ../../../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../..; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../../../sam0/drivers/usb/stack_interface; ..; ../../../../../../../../../sam0/drivers/port; ../..; ../../../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example_flash.bin
  ILINK.IlinkOutputFile: host_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_host_uhd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e17b.h saml21e15b.h saml21j18b.h saml21e16b.h saml21e18b.h saml21j16b.h saml21g17b.h saml21j17b.h saml21g16b.h saml21g18b.h saml21.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: sercom4.h eic.h evsys.h adc.h opamp.h dsu.h tal.h tc1.h sercom0.h sercom2.h pm.h nvmctrl.h rtc.h tc0.h tc3.h trng.h aes.h mclk.h supc.h tcc2.h dac.h gclk.h ac.h oscctrl.h tc2.h usb.h tcc0.h ccl.h port.h sercom5.h tc4.h wdt.h osc32kctrl.h pac.h sercom1.h mtb.h dmac.h tcc1.h rstc.h sercom3.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21g17b.h saml21g16b.h saml21e16b.h saml21j18b.h saml21e17b.h saml21j16b.h saml21e18b.h saml21g18b.h saml21j17b.h saml21e15b.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../../../../sam0/utils/cmsis/saml21/include_b/component/: tal.h sercom.h mclk.h opamp.h tcc.h port.h adc.h mtb.h dmac.h dac.h ccl.h evsys.h rstc.h osc32kctrl.h gclk.h oscctrl.h dsu.h supc.h nvmctrl.h usb.h wdt.h eic.h rtc.h tc.h trng.h aes.h ac.h pm.h pac.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h stringz.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/vendor
    ../../../../: usb_protocol_vendor.h
  group common/services/usb/class/vendor/host
    ../../../: uhi_vendor.c uhi_vendor.h
  group common/services/usb/class/vendor/host/example
    ../../: main.c conf_usb_host.h main.h ui.h
  group common/services/usb/class/vendor/host/example/saml21j18b_saml21_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/vendor/host/example/saml21j18b_saml21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
