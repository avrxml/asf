# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD21_XPLAINED_PRO; __SAMD21J18A__; SPI_CALLBACK_MODE=true; SYSTICK_MODE
  ICCARM.CCIncludePath2: ../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/utils/preprocessor; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils/cmsis/samd21/include/component; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/boards; ../../..; ../../../../../../../sam0/utils/cmsis/samd21/include/pio; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../services/delay/sam0; ../../../../../../../sam0/utils/cmsis/samd21/include/instance; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/boards/samd21_xplained_pro; ..; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../: ssd1306.c ssd1306.h
  group common2/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common2/components/display/ssd1306/example/samd21_xplained_pro
    ../: conf_ssd1306.h conf_board.h conf_spi.h conf_clocks.h
  group common2/components/display/ssd1306/example/samd21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: systick_counter.c systick_counter.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../sam0/utils/cmsis/samd21/include/: samd21.h samd21g18a.h samd21j18a.h samd21e16a.h samd21e18a.h samd21e17a.h samd21j17a.h samd21g17a.h samd21e15a.h samd21j16a.h samd21g16a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../sam0/utils/cmsis/samd21/include/instance/: instance_dmac.h instance_evsys.h instance_pm.h instance_nvmctrl.h instance_sysctrl.h instance_tcc2.h instance_ac.h instance_tcc0.h instance_tc6.h instance_tc4.h instance_wdt.h instance_tc3.h instance_usb.h instance_tc7.h instance_i2s.h instance_sercom4.h instance_port.h instance_sercom1.h instance_tc5.h instance_sercom0.h instance_rtc.h instance_dac.h instance_pac1.h instance_pac0.h instance_sercom2.h instance_mtb.h instance_sercom5.h instance_dsu.h instance_gclk.h instance_adc.h instance_eic.h instance_tcc1.h instance_sercom3.h instance_pac2.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../sam0/utils/cmsis/samd21/include/component/: component_i2s.h component_pm.h component_tc.h component_wdt.h component_tcc.h component_dsu.h component_eic.h component_adc.h component_port.h component_gclk.h component_pac.h component_usb.h component_nvmctrl.h component_sysctrl.h component_dac.h component_dmac.h component_mtb.h component_evsys.h component_ac.h component_rtc.h component_sercom.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../sam0/utils/cmsis/samd21/include/pio/: pio_samd21e15a.h pio_samd21j18a.h pio_samd21e16a.h pio_samd21g18a.h pio_samd21j16a.h pio_samd21e18a.h pio_samd21j17a.h pio_samd21g16a.h pio_samd21e17a.h pio_samd21g17a.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
