# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; CYCLE_MODE; BOARD=SAMD20_XPLAINED_PRO; __SAMD20J18__; RTC_CALENDAR_ASYNC=false; SD_MMC_ENABLE; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../../sam0/drivers/rtc; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/utils/cmsis/samd20/include/component; ../../../../../../services/delay/sam0; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../../../../sam0/utils/cmsis/samd20/include/pio; ../../../../../../../common/boards; ../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/utils/cmsis/samd20/include/instance; ../../../../../../../sam0/drivers/system; ..; ../..; ../../..; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../common/services/storage/ctrl_access; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../sam0/utils/cmsis/samd20/include/: samd20e16.h samd20g17.h samd20g15.h samd20j18.h samd20e14.h samd20g16.h samd20g14.h samd20.h samd20g18.h samd20j14.h samd20j16.h samd20e17.h samd20j15.h samd20e15.h samd20j17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../sam0/utils/cmsis/samd20/include/instance/: instance_pac2.h instance_sercom1.h instance_sercom3.h instance_pac0.h instance_sercom5.h instance_sercom0.h instance_nvmctrl.h instance_ac.h instance_sercom2.h instance_eic.h instance_pac1.h instance_dsu.h instance_dac.h instance_pm.h instance_tc5.h instance_sercom4.h instance_port.h instance_tc3.h instance_gclk.h instance_tc1.h instance_wdt.h instance_tc7.h instance_tc4.h instance_rtc.h instance_adc.h instance_sysctrl.h instance_tc2.h instance_evsys.h instance_tc0.h instance_tc6.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../sam0/utils/cmsis/samd20/include/pio/: pio_samd20j18.h pio_samd20g17.h pio_samd20g15.h pio_samd20j15.h pio_samd20e15.h pio_samd20j16.h pio_samd20g14.h pio_samd20g16.h pio_samd20e16.h pio_samd20j17.h pio_samd20e14.h pio_samd20j14.h pio_samd20e17.h pio_samd20e1f.h pio_samd20g18.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../sam0/utils/cmsis/samd20/include/component/: component_eic.h component_ac.h component_gclk.h component_dac.h component_evsys.h component_sysctrl.h component_port.h component_dsu.h component_rtc.h component_pac.h component_sercom.h component_pm.h component_nvmctrl.h component_wdt.h component_tc.h component_adc.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../sam0/drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_calendar.c rtc_calendar.h
  group sam0/drivers/rtc/quick_start_calendar
    ../../../../../../../sam0/drivers/rtc/quick_start_calendar/: qs_rtc_calendar_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h sd_mmc_mem.h
  group common2/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common2/components/memory/sd_mmc/example2/samd20j18_samd20_xplained_pro
    ../: conf_board.h conf_sd_mmc.h conf_sleepmgr.h conf_example.h conf_spi.h conf_clocks.h
  group common2/components/memory/sd_mmc/example2/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: cycle_counter.c cycle_counter.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
  group common/services/storage/ctrl_access
    ../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
