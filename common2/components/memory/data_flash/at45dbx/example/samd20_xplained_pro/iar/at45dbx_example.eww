<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at45dbx_example_flash.ewp</path>
	</project>
</workspace>
