# IAR project at45dbx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; SPI_CALLBACK_MODE=false; BOARD=SAMD20_XPLAINED_PRO; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/utils/cmsis/samd20/include/pio; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/drivers/port; ../../../../../../../../common/boards; ../../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/utils/cmsis/samd20/include/instance; ../../..; ../../../../../../../../sam0/drivers/system; ../../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../../common/utils; ../../../../../../../../sam0/utils/cmsis/samd20/source; ..; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/utils/cmsis/samd20/include/component; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at45dbx_example_flash.bin
  ILINK.IlinkOutputFile: at45dbx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.c clock.c gclk.h clock.h clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../../sam0/utils/cmsis/samd20/include/: samd20g18.h samd20g16.h samd20j18.h samd20j14.h samd20e14.h samd20g14.h samd20j17.h samd20e16.h samd20g15.h samd20j16.h samd20e17.h samd20e15.h samd20.h samd20e18.h samd20j15.h samd20g17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd20/include/instance/: instance_tc2.h instance_sercom5.h instance_rtc.h instance_tc4.h instance_ac.h instance_tc7.h instance_tc1.h instance_sysctrl.h instance_tc3.h instance_sercom3.h instance_wdt.h instance_sercom1.h instance_tc5.h instance_gclk.h instance_evsys.h instance_sercom2.h instance_adc.h instance_dac.h instance_sercom4.h instance_eic.h instance_pac1.h instance_sercom0.h instance_pm.h instance_dsu.h instance_port.h instance_pac2.h instance_tc6.h instance_tc0.h instance_pac0.h instance_nvmctrl.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd20/include/pio/: pio_samd20g16.h pio_samd20j17.h pio_samd20g14.h pio_samd20j15.h pio_samd20j18.h pio_samd20g17.h pio_samd20j16.h pio_samd20g15.h pio_samd20e14.h pio_samd20j14.h pio_samd20e16.h pio_samd20g18.h pio_samd20e15.h pio_samd20e18.h pio_samd20e17.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../../sam0/utils/cmsis/samd20/include/component/: component_pac.h component_wdt.h component_tc.h component_dsu.h component_nvmctrl.h component_port.h component_evsys.h component_dac.h component_gclk.h component_pm.h component_sercom.h component_adc.h component_rtc.h component_sysctrl.h component_ac.h component_eic.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common2/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group common2/components/memory/data_flash/at45dbx/example/samd20_xplained_pro
    ../: conf_data_flash_example.h conf_board.h conf_at45dbx.h conf_clocks.h
  group common2/components/memory/data_flash/at45dbx/example/samd20_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
