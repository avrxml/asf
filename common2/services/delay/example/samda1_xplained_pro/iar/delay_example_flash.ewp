# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/utils/cmsis/samda1/include; ..; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/boards/samda1_xplained_pro; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda; ../../../sam0; ../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../sam0/utils/cmsis/samda1/source; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samda1_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samda1_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../sam0/utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../sam0/utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../sam0/utils/cmsis/samda1/include/: samda1g15b.h samda1j14a.h samda1g14a.h samda1e16b.h samda1g16b.h samda1j16a.h samda1e16a.h samda1g16a.h samda1e15a.h samda1e14b.h samda1j16b.h samda1.h samda1j14b.h samda1g15a.h samda1j15a.h samda1j15b.h samda1g14b.h samda1e15b.h samda1e14a.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../sam0/utils/cmsis/samda1/include/instance/: tcc2.h pac0.h dsu.h tcc0.h i2s.h evsys.h mtb.h rtc.h ac.h sercom0.h tc7.h sbmatrix.h eic.h port.h tc3.h tc6.h sercom4.h tc4.h sercom3.h wdt.h nvmctrl.h tc5.h dmac.h sercom1.h pac1.h dac.h sercom5.h sercom2.h adc.h gclk.h pm.h tcc1.h usb.h pac2.h sysctrl.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../sam0/utils/cmsis/samda1/include/pio/: samda1g14a.h samda1e16b.h samda1g16a.h samda1e15a.h samda1g14b.h samda1g15b.h samda1j16b.h samda1e15b.h samda1e14b.h samda1g15a.h samda1j16a.h samda1j15a.h samda1g16b.h samda1j14b.h samda1j15b.h samda1e16a.h samda1j14a.h samda1e14a.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../sam0/utils/cmsis/samda1/include/component/: tc.h sercom.h evsys.h hmatrixb.h dmac.h rtc.h gclk.h dsu.h dac.h mtb.h tcc.h eic.h pm.h port.h usb.h adc.h wdt.h pac.h nvmctrl.h sysctrl.h ac.h i2s.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: tpaste.h preprocessor.h mrecursion.h stringz.h mrepeat.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../../sam0/boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
