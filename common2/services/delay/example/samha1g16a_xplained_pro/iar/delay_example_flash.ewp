# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; __SAMHA1G16A__; BOARD=SAMHA1G16A_XPLAINED_PRO; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/utils/cmsis/samha1/include; ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/utils/cmsis/samha1/source; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ..; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samha; ../../../sam0; ../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/boards/samha1g16a_xplained_pro; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../../sam0/utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../../sam0/utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../../sam0/utils/cmsis/samha1/include/: samha1.h samha1e14a.h samha1g14ab.h samha1e16ab.h samha1e14ab.h samha1g15ab.h samha1g15a.h samha1g16ab.h samha1g16a.h samha1e15ab.h samha1e16a.h samha1g14a.h samha1e15a.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../../sam0/utils/cmsis/samha1/include/component/: hmatrixb.h eic.h linctrl.h port.h mtb.h adc.h evsys.h sysctrl.h gclk.h tcc.h pm.h ac.h dmac.h rtc.h dsu.h pac.h wdt.h nvmctrl.h dac.h tc.h sercom.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../../sam0/utils/cmsis/samha1/include/instance/: evsys.h port.h tc3.h nvmctrl.h sysctrl.h dac.h tcc1.h tc6.h wdt.h gclk.h sercom4.h pac0.h linctrl.h mtb.h pac1.h sercom2.h eic.h tc7.h tcc2.h sercom0.h tc4.h sbmatrix.h ac.h rtc.h pac2.h tcc0.h sercom3.h sercom5.h sercom1.h tc5.h dmac.h adc.h dsu.h pm.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../../sam0/utils/cmsis/samha1/include/pio/: samha1e14ab.h samha1e14a.h samha1e15a.h samha1e15ab.h samha1g14ab.h samha1g16a.h samha1g15a.h samha1g16ab.h samha1e16a.h samha1g15ab.h samha1g14a.h samha1e16ab.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samha
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samha/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../../sam0/boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samha1g16a_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samha1g16a_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
