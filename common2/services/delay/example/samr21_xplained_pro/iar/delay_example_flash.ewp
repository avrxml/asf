# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__; ARM_MATH_CM0=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/system/clock/clock_samd21_r21; ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/utils/cmsis/samr21/source; ../../..; ../../../../../../sam0/utils; ..; ../../../../../../sam0/boards; ../../../../../../sam0/utils/cmsis/samr21/include/instance; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/utils/cmsis/samr21/include/pio; ../../../../../../sam0/utils/cmsis/samr21/include/component; ../../../sam0; ../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../sam0/utils/cmsis/samr21/include; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../sam0/utils/cmsis/samr21/include/: samr21g18a.h samr21e17a.h samr21e16a.h samr21e18a.h samr21g17a.h samr21g16a.h samr21.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../sam0/utils/cmsis/samr21/include/instance/: instance_usb.h instance_eic.h instance_tcc0.h instance_dsu.h instance_i2s.h instance_dmac.h instance_tcc2.h instance_tcc1.h instance_pm.h instance_mtb.h instance_dac.h instance_port.h instance_rfctrl.h instance_wdt.h instance_ac.h instance_pac0.h instance_tc3.h instance_sercom3.h instance_pac2.h instance_sercom1.h instance_adc.h instance_rtc.h instance_sercom5.h instance_tc5.h instance_pac1.h instance_tc7.h instance_sercom2.h instance_sercom0.h instance_evsys.h instance_sysctrl.h instance_sercom4.h instance_tc4.h instance_tc6.h instance_nvmctrl.h instance_gclk.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../sam0/utils/cmsis/samr21/include/component/: component_i2s.h component_nvmctrl.h component_rtc.h component_rfctrl.h component_dac.h component_evsys.h component_port.h component_ac.h component_adc.h component_pm.h component_sercom.h component_sysctrl.h component_pac.h component_gclk.h component_eic.h component_tcc.h component_usb.h component_dmac.h component_mtb.h component_tc.h component_wdt.h component_dsu.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../sam0/utils/cmsis/samr21/include/pio/: pio_samr21g18a.h pio_samr21e17a.h pio_samr21g16a.h pio_samr21g17a.h pio_samr21e16a.h pio_samr21e18a.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samr21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
