# IAR project cmsis_cm4_cmsis_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../sam4l/source/templates; ../../../../../boards/sam4l_ek; ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../header_files; ../../../../../drivers/flashcalw; ../../../../preprocessor; ../../../../../../common/boards; ../../../sam4l/include; ../../../../../../common/services/ioport; ../../../../../drivers/bpm; ../../../../../../common/utils; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_cmsis_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_cmsis_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/cmsis/cm4_cmsis_example
    ../../: main.c
  group sam/utils/cmsis/cm4_cmsis_example/sam4lc4c_sam4l_ek
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_cmsis_example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/drivers/flashcalw
    ../../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/bpm
    ../../../../../drivers/bpm/: bpm.c bpm.h
  group sam/boards/sam4l_ek
    ../../../../../boards/sam4l_ek/: init.c sam4l_ek.h led.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h osc.h dfll.h pll.h genclk.h
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c sysclk.c dfll.c pll.c pll.h sysclk.h osc.h dfll.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
