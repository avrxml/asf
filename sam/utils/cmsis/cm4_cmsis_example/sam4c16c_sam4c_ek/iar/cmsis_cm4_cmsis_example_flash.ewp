# IAR project cmsis_cm4_cmsis_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../sam4c/include; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../sam4c/source/templates; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../boards/sam4c_ek; ../../../../../../common/utils; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_cmsis_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_cmsis_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../sam4c/include/: sam4c16c_0.h sam4c32c_0.h sam4c32e_1.h sam4c.h sam4c16c_1.h sam4c32c_1.h sam4c8c_1.h system_sam4c.h sam4c32e_0.h sam4c8c_0.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../sam4c/include/pio/: pio_sam4c32e.h pio_sam4c8c.h pio_sam4c32c.h pio_sam4c16c.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../sam4c/include/instance/: instance_trng.h instance_tc0.h instance_spi1.h instance_usart0.h instance_usart2.h instance_piod.h instance_matrix1.h instance_chipid.h instance_spi0.h instance_rswdt.h instance_usart3.h instance_pioa.h instance_pwm.h instance_tc1.h instance_efc1.h instance_smc0.h instance_icm.h instance_rtt.h instance_pmc.h instance_usart1.h instance_wdt.h instance_piob.h instance_rstc.h instance_efc0.h instance_efc.h instance_usart4.h instance_smc1.h instance_cmcc0.h instance_supc.h instance_rtc.h instance_slcdc.h instance_twi1.h instance_uart1.h instance_uotghs.h instance_ipc1.h instance_cmcc1.h instance_matrix0.h instance_gpbr.h instance_aes.h instance_adc.h instance_pioc.h instance_ipc0.h instance_twi0.h instance_uart0.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../sam4c/include/component/: component_trng.h component_spi.h component_pdc.h component_twi.h component_pmc.h component_wdt.h component_usart.h component_pwm.h component_matrix.h component_supc.h component_ipc.h component_gpbr.h component_adc.h component_efc.h component_uart.h component_cmcc.h component_pio.h component_rtc.h component_chipid.h component_rswdt.h component_rstc.h component_icm.h component_smc.h component_uotghs.h component_aes.h component_rtt.h component_slcdc.h component_tc.h
  group sam/utils/cmsis/cm4_cmsis_example
    ../../: main.c
  group sam/utils/cmsis/cm4_cmsis_example/sam4c16c_sam4c_ek
    ../: conf_board.h conf_clock.h
  group sam/utils/cmsis/cm4_cmsis_example/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/sam4c_ek
    ../../../../../boards/sam4c_ek/: init.c sam4c_ek.h led.h
