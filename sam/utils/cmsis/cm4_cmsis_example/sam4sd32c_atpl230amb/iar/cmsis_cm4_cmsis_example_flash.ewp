# IAR project cmsis_cm4_cmsis_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../sam4s/source/templates; ../../../../../drivers/supc; ../../../../../boards/atpl230amb; ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ..; ../../../../../../common/utils; ../../../sam4s/include; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_cmsis_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_cmsis_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/supc
    ../../../../../drivers/supc/: supc.c supc.h
  group sam/boards/atpl230amb
    ../../../../../boards/atpl230amb/: init.c led.h atpl230amb.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/cm4_cmsis_example
    ../../: main.c
  group sam/utils/cmsis/cm4_cmsis_example/sam4sd32c_atpl230amb
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_cmsis_example/sam4sd32c_atpl230amb/iar
    ./: asf.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../sam4s/include/: sam4s4a.h sam4s16c.h sam4s8c.h sam4s4c.h sam4s2b.h sam4s8b.h sam4sa16c.h sam4sd32c.h sam4s.h sam4sa16b.h system_sam4s.h sam4sd16c.h sam4sd16b.h sam4s4b.h sam4s16b.h sam4sd32b.h sam4s2a.h sam4s2c.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../sam4s/include/component/: component_usart.h component_supc.h component_crccu.h component_rtc.h component_pmc.h component_tc.h component_udp.h component_pdc.h component_adc.h component_cmcc.h component_chipid.h component_efc.h component_uart.h component_rtt.h component_acc.h component_wdt.h component_hsmci.h component_ssc.h component_smc.h component_gpbr.h component_pio.h component_pwm.h component_rstc.h component_dacc.h component_spi.h component_matrix.h component_twi.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../sam4s/include/instance/: instance_hsmci.h instance_uart1.h instance_pwm.h instance_spi.h instance_gpbr.h instance_twi0.h instance_acc.h instance_crccu.h instance_ssc.h instance_rstc.h instance_uart0.h instance_pioa.h instance_pioc.h instance_tc0.h instance_udp.h instance_dacc.h instance_chipid.h instance_usart0.h instance_piob.h instance_pmc.h instance_efc1.h instance_supc.h instance_rtt.h instance_matrix.h instance_cmcc.h instance_wdt.h instance_smc.h instance_adc.h instance_rtc.h instance_efc0.h instance_twi1.h instance_usart1.h instance_tc1.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../sam4s/include/pio/: pio_sam4s16b.h pio_sam4sa16c.h pio_sam4sd16b.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s8c.h pio_sam4s4a.h pio_sam4s2c.h pio_sam4s8b.h pio_sam4s4c.h pio_sam4s2a.h pio_sam4s16c.h pio_sam4sd32b.h pio_sam4s4b.h pio_sam4s2b.h pio_sam4sd32c.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
