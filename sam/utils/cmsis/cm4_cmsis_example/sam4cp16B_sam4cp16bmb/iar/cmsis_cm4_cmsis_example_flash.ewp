# IAR project cmsis_cm4_cmsis_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../../common/services/ioport; ..; ../../../sam4cp/source/templates; ../../../../../drivers/supc; ../../../../../../common/utils; ../../../../../drivers/pmc; ../../../sam4cp/include; ../../../../../boards/sam4cp16bmb; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_cmsis_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_cmsis_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/supc
    ../../../../../drivers/supc/: supc.c supc.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../sam4cp/include/: system_sam4cp.h sam4cp.h sam4cp16b_1.h sam4cp_0.h sam4cp16b_0.h sam4cp_1.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../sam4cp/include/instance/: instance_aes.h instance_usart3.h instance_spi1.h instance_ipc0.h instance_twi1.h instance_tc0.h instance_uart1.h instance_gpbr.h instance_twi0.h instance_smc0.h instance_usart1.h instance_pwm.h instance_spi0.h instance_efc.h instance_tc1.h instance_icm.h instance_rtc.h instance_smc1.h instance_rswdt.h instance_uart0.h instance_slcdc.h instance_pioa.h instance_rstc.h instance_pmc.h instance_cmcc1.h instance_supc.h instance_adc.h instance_pioc.h instance_usart2.h instance_usart0.h instance_ipc1.h instance_trng.h instance_usart4.h instance_rtt.h instance_piob.h instance_wdt.h instance_matrix0.h instance_cmcc0.h instance_matrix1.h instance_chipid.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../sam4cp/include/component/: component_twi.h component_wdt.h component_rswdt.h component_pio.h component_chipid.h component_usart.h component_adc.h component_slcdc.h component_trng.h component_rstc.h component_pmc.h component_uart.h component_icm.h component_pwm.h component_tc.h component_spi.h component_aes.h component_matrix.h component_smc.h component_rtc.h component_efc.h component_supc.h component_cmcc.h component_rtt.h component_gpbr.h component_pdc.h component_ipc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/cmsis/cm4_cmsis_example
    ../../: main.c
  group sam/utils/cmsis/cm4_cmsis_example/sam4cp16B_sam4cp16bmb
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_cmsis_example/sam4cp16B_sam4cp16bmb/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/sam4cp16bmb
    ../../../../../boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4cp
    ../../../../../../common/services/clock/sam4cp/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
