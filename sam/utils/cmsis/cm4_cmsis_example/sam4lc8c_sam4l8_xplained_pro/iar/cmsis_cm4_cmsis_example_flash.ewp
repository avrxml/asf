# IAR project cmsis_cm4_cmsis_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC8C__; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../drivers/wdt; ../../../sam4l/source/templates; ../../../..; ../../../../../../common/services/clock; ..; ../../../../header_files; ../../../../../drivers/flashcalw; ../../../../preprocessor; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../boards/sam4l8_xplained_pro; ../../../../../boards; ../../../../../drivers/bpm; ../../../../../../common/utils; ../../../sam4l/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4LC8C__; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_cmsis_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_cmsis_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../sam4l/include/: sam4ls4a.h sam4lc2a.h sam4lc4c.h sam4ls4b.h sam4ls2b.h sam4lc4a.h sam4ls4c.h sam4ls2a.h sam4ls2c.h sam4ls8b.h sam4ls8a.h sam4lc8b.h sam4ls8c.h sam4lc2c.h sam4lc2b.h sam4lc8c.h sam4lc8a.h sam4lc4b.h sam4l.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../sam4l/include/pio/: pio_sam4ls2c.h pio_sam4lc4a.h pio_sam4lc4c.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4lc4b.h pio_sam4lc2b.h pio_sam4ls8b.h pio_sam4ls4b.h pio_sam4lc8c.h pio_sam4lc2c.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2a.h pio_sam4ls2b.h pio_sam4lc8b.h pio_sam4lc8a.h pio_sam4lc2a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../sam4l/include/instance/: instance_pm.h instance_adcife.h instance_gloc.h instance_pdca.h instance_picouart.h instance_tc0.h instance_chipid.h instance_iisc.h instance_usart0.h instance_scif.h instance_trng.h instance_bpm.h instance_ast.h instance_acifc.h instance_usbc.h instance_spi.h instance_bscif.h instance_crccu.h instance_lcdca.h instance_pevc.h instance_freqm.h instance_gpio.h instance_twis1.h instance_hflashc.h instance_usart2.h instance_smap.h instance_dacc.h instance_tc1.h instance_wdt.h instance_catb.h instance_twis0.h instance_twim3.h instance_eic.h instance_twim1.h instance_hcache.h instance_aesa.h instance_parc.h instance_hmatrix.h instance_twim2.h instance_usart1.h instance_twim0.h instance_abdacb.h instance_usart3.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../sam4l/include/component/: component_pm.h component_wdt.h component_gpio.h component_bpm.h component_gloc.h component_freqm.h component_adcife.h component_dacc.h component_smap.h component_chipid.h component_scif.h component_eic.h component_crccu.h component_twim.h component_flashcalw.h component_aesa.h component_hmatrixb.h component_usart.h component_twis.h component_trng.h component_abdacb.h component_bscif.h component_iisc.h component_tc.h component_usbc.h component_catb.h component_pdca.h component_acifc.h component_picouart.h component_spi.h component_pevc.h component_lcdca.h component_parc.h component_hcache.h component_ast.h
  group sam/utils/cmsis/cm4_cmsis_example
    ../../: main.c
  group sam/utils/cmsis/cm4_cmsis_example/sam4lc8c_sam4l8_xplained_pro
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_cmsis_example/sam4lc8c_sam4l8_xplained_pro/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../boards/sam4l8_xplained_pro/: init.c sam4l8_xplained_pro.h led.h
  group sam/drivers/flashcalw
    ../../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/bpm
    ../../../../../drivers/bpm/: bpm.c bpm.h
  group sam/drivers/wdt
    ../../../../../drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c sysclk.c dfll.c pll.c dfll.h genclk.h sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
