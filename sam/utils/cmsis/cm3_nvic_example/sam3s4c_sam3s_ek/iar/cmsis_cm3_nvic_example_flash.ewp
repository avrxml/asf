# IAR project cmsis_cm3_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../header_files; ../../../../../drivers/uart; ../..; ../../../..; ../../../../../boards/sam3s_ek; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../drivers/usart; ../../../sam3s/include; ..; ../../../../preprocessor; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../sam3s/source/templates; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../sam3s/source/templates/: exceptions.c system_sam3s.c system_sam3s.h exceptions.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../sam3s/include/: sam3s2a.h sam3s1b.h sam3s4c.h sam3s2c.h sam3s4a.h sam3s.h sam3s1c.h sam3s4b.h sam3s2b.h sam3s1a.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../sam3s/include/instance/: instance_rtc.h instance_piob.h instance_acc.h instance_chipid.h instance_rtt.h instance_twi1.h instance_tc1.h instance_uart0.h instance_smc.h instance_supc.h instance_pmc.h instance_usart0.h instance_tc0.h instance_uart1.h instance_gpbr.h instance_pioc.h instance_pwm.h instance_udp.h instance_matrix.h instance_wdt.h instance_dacc.h instance_spi.h instance_rstc.h instance_usart1.h instance_pioa.h instance_ssc.h instance_efc.h instance_crccu.h instance_twi0.h instance_adc.h instance_hsmci.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../sam3s/include/pio/: pio_sam3s2b.h pio_sam3s4c.h pio_sam3s4b.h pio_sam3s1b.h pio_sam3s4a.h pio_sam3s1c.h pio_sam3s1a.h pio_sam3s2c.h pio_sam3s2a.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../sam3s/include/component/: component_smc.h component_rtt.h component_pio.h component_uart.h component_spi.h component_usart.h component_pmc.h component_supc.h component_ssc.h component_rstc.h component_acc.h component_dacc.h component_rtc.h component_gpbr.h component_crccu.h component_pwm.h component_tc.h component_twi.h component_chipid.h component_pdc.h component_hsmci.h component_adc.h component_efc.h component_udp.h component_matrix.h component_wdt.h
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/utils/cmsis/cm3_nvic_example/sam3s4c_sam3s_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/utils/cmsis/cm3_nvic_example/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: led.c init.c led.h sam3s_ek.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
