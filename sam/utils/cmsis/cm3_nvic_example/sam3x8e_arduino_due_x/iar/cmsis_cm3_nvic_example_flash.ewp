# IAR project cmsis_cm3_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../header_files; ../../../../../drivers/uart; ../..; ../../../..; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../preprocessor; ../../../sam3x/include; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards/arduino_due_x; ../../../../../boards; ../../../../../../common/utils; ..; ../../../../../../common/services/serial; ../../../sam3x/source/templates; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../sam3x/source/templates/: system_sam3x.c exceptions.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../sam3x/include/: sam3x8h.h sam3x8e.h sam3x4c.h sam3x8c.h sam3a4c.h sam3xa.h sam3a8c.h sam3x4e.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../sam3x/include/instance/: instance_uart.h instance_dacc.h instance_pioc.h instance_usart0.h instance_hsmci.h instance_rtc.h instance_pmc.h instance_pwm.h instance_piob.h instance_usart1.h instance_usart2.h instance_rstc.h instance_pioe.h instance_spi1.h instance_pioa.h instance_can1.h instance_emac.h instance_dmac.h instance_sdramc.h instance_adc.h instance_piof.h instance_supc.h instance_piod.h instance_spi0.h instance_twi1.h instance_usart3.h instance_tc0.h instance_uotghs.h instance_tc2.h instance_efc1.h instance_chipid.h instance_trng.h instance_can0.h instance_twi0.h instance_tc1.h instance_gpbr.h instance_smc.h instance_rtt.h instance_matrix.h instance_efc0.h instance_wdt.h instance_ssc.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../sam3x/include/component/: component_pio.h component_dacc.h component_dmac.h component_uotghs.h component_hsmci.h component_rstc.h component_tc.h component_twi.h component_wdt.h component_chipid.h component_rtt.h component_usart.h component_spi.h component_gpbr.h component_uart.h component_sdramc.h component_pdc.h component_smc.h component_efc.h component_trng.h component_matrix.h component_supc.h component_pmc.h component_rtc.h component_emac.h component_ssc.h component_pwm.h component_adc.h component_can.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../sam3x/include/pio/: pio_sam3x8e.h pio_sam3x8h.h pio_sam3a4c.h pio_sam3a8c.h pio_sam3x8c.h pio_sam3x4c.h pio_sam3x4e.h
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/utils/cmsis/cm3_nvic_example/sam3x8e_arduino_due_x
    ../: conf_uart_serial.h conf_board.h conf_clock.h
  group sam/utils/cmsis/cm3_nvic_example/sam3x8e_arduino_due_x/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h stringz.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/arduino_due_x
    ../../../../../boards/arduino_due_x/: init.c arduino_due_x.h
