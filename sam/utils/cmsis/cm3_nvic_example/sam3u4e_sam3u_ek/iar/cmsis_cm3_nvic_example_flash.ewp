# IAR project cmsis_cm3_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ..; ../../../../header_files; ../../../../../drivers/uart; ../..; ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../boards/sam3u_ek; ../../../sam3u/include; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../sam3u/source/templates; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: led.c init.c led.h sam3u_ek.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../sam3u/source/templates/: system_sam3u.c exceptions.c exceptions.h system_sam3u.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../sam3u/include/: sam3u2c.h sam3u2e.h sam3u.h sam3u4c.h sam3u4e.h sam3u1c.h sam3u1e.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../sam3u/include/instance/: instance_chipid.h instance_gpbr.h instance_usart3.h instance_adc12b.h instance_pioa.h instance_pwm.h instance_usart1.h instance_twi1.h instance_piob.h instance_ssc.h instance_wdt.h instance_usart2.h instance_dmac.h instance_pmc.h instance_spi.h instance_usart0.h instance_hsmci.h instance_adc.h instance_rtt.h instance_pioc.h instance_tc0.h instance_udphs.h instance_supc.h instance_rstc.h instance_efc0.h instance_rtc.h instance_matrix.h instance_twi0.h instance_smc.h instance_uart.h instance_efc1.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../sam3u/include/component/: component_supc.h component_wdt.h component_efc.h component_gpbr.h component_smc.h component_ssc.h component_pdc.h component_pmc.h component_twi.h component_adc12b.h component_tc.h component_chipid.h component_rstc.h component_spi.h component_matrix.h component_rtc.h component_pio.h component_udphs.h component_rtt.h component_uart.h component_adc.h component_usart.h component_hsmci.h component_pwm.h component_dmac.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../sam3u/include/pio/: pio_sam3u4e.h pio_sam3u4c.h pio_sam3u2c.h pio_sam3u1c.h pio_sam3u1e.h pio_sam3u2e.h
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/utils/cmsis/cm3_nvic_example/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/utils/cmsis/cm3_nvic_example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
