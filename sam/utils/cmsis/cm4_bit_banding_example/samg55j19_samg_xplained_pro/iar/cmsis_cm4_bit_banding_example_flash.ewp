# IAR project cmsis_cm4_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../samg/samg55/source/templates; ../../../..; ../../../../fpu; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../../common/services/clock; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/supc; ../../../../../../common/utils; ../../../samg/samg55/include; ..; ../../../../../boards/samg55_xplained_pro; ../../../../../drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../samg/samg55/include/: samg55g18.h samg55j19.h system_samg55.h samg55g19.h samg55j18.h samg55n19.h samg55.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../samg/samg55/include/instance/: rtc.h usart5.h usart7.h usart3.h tc1.h spi5.h tc0.h twi0.h spi1.h twi2.h spi7.h flexcom6.h i2sc1.h efc.h usart4.h usart2.h wdt.h rtt.h flexcom4.h pdmic0.h crccu.h usart1.h twi1.h flexcom0.h flexcom7.h twi3.h gpbr.h flexcom2.h twi4.h supc.h mem2mem.h spi2.h spi0.h flexcom5.h usart6.h piob.h uhp.h usart0.h flexcom1.h twi7.h twi6.h matrix.h udp.h flexcom3.h chipid.h pdmic1.h pmc.h spi3.h pioa.h spi4.h adc.h twi5.h i2sc0.h cmcc.h spi6.h rstc.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../samg/samg55/include/component/: pmc.h cmcc.h chipid.h crccu.h rtt.h uhp.h pio.h rtc.h gpbr.h mem2mem.h efc.h spi.h pdmic.h twi.h tc.h i2sc.h rstc.h matrix.h supc.h flexcom.h wdt.h adc.h usart.h udp.h pdc.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../samg/samg55/include/pio/: samg55j19.h samg55n19.h samg55g19.h samg55j18.h samg55g18.h
  group sam/utils/cmsis/cm4_bit_banding_example
    ../../: main.c
  group sam/utils/cmsis/cm4_bit_banding_example/samg55j19_samg_xplained_pro
    ../: conf_board.h conf_clock.h
  group sam/utils/cmsis/cm4_bit_banding_example/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group sam/utils/fpu
    ../../../../fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../drivers/supc/: supc.c supc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
