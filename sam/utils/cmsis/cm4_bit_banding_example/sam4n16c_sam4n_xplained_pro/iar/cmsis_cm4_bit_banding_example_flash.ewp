# IAR project cmsis_cm4_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../sam4n/include; ../../../..; ../../../../../boards/sam4n_xplained_pro; ../../../sam4n/source/templates; ../../../../../../common/services/clock; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ..; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../../common/utils; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../sam4n/source/templates/: system_sam4n.c exceptions.c exceptions.h system_sam4n.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../sam4n/include/: sam4n.h sam4n16b.h sam4n8c.h sam4n8a.h sam4n8b.h sam4n16c.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../sam4n/include/component/: component_matrix.h component_pdc.h component_gpbr.h component_wdt.h component_dacc.h component_uart.h component_spi.h component_pmc.h component_rstc.h component_usart.h component_pio.h component_tc.h component_rtt.h component_efc.h component_adc.h component_rtc.h component_chipid.h component_twi.h component_supc.h component_pwm.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../sam4n/include/instance/: instance_rtc.h instance_piob.h instance_pwm.h instance_uart0.h instance_twi1.h instance_supc.h instance_rstc.h instance_usart1.h instance_usart2.h instance_uart2.h instance_pmc.h instance_pioc.h instance_uart1.h instance_pioa.h instance_usart0.h instance_tc1.h instance_uart3.h instance_adc.h instance_twi2.h instance_matrix.h instance_wdt.h instance_tc0.h instance_chipid.h instance_dacc.h instance_spi.h instance_rtt.h instance_gpbr.h instance_efc.h instance_twi0.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../sam4n/include/pio/: pio_sam4n8c.h pio_sam4n16b.h pio_sam4n8a.h pio_sam4n16c.h pio_sam4n8b.h
  group sam/utils/cmsis/cm4_bit_banding_example
    ../../: main.c
  group sam/utils/cmsis/cm4_bit_banding_example/sam4n16c_sam4n_xplained_pro
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_bit_banding_example/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4n
    ../../../../../../common/services/clock/sam4n/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
