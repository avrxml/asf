<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cmsis_cm4_bit_banding_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\cmsis_cm4_bit_banding_example_sram.ewp</path>
	</project>
</workspace>
