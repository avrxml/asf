# IAR project cmsis_cm4_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../sam4s/source/templates; ../../../../header_files; ../../../../../drivers/uart; ..; ../../../..; ../../../../../../common/services/clock; ../..; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../boards/sam4s_ek2; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards; ../../../../../../common/utils; ../../../sam4s/include; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/boards/sam4s_ek2
    ../../../../../boards/sam4s_ek2/: init.c led.c led.h sam4s_ek2.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../sam4s/source/templates/: exceptions.c system_sam4s.c exceptions.h system_sam4s.h
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../sam4s/include/: sam4s16c.h sam4s8c.h sam4s8b.h sam4sa16c.h sam4sd32c.h sam4s.h sam4sa16b.h sam4sd16c.h sam4sd16b.h sam4s16b.h sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../sam4s/include/component/: component_usart.h component_supc.h component_crccu.h component_rtc.h component_tc.h component_udp.h component_pdc.h component_adc.h component_cmcc.h component_chipid.h component_efc.h component_uart.h component_rtt.h component_gpbr.h component_acc.h component_wdt.h component_hsmci.h component_pmc.h component_ssc.h component_smc.h component_pio.h component_pwm.h component_rstc.h component_dacc.h component_spi.h component_matrix.h component_twi.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../sam4s/include/instance/: instance_hsmci.h instance_uart1.h instance_pwm.h instance_supc.h instance_spi.h instance_gpbr.h instance_twi0.h instance_acc.h instance_crccu.h instance_ssc.h instance_rstc.h instance_uart0.h instance_rtc.h instance_pioa.h instance_pioc.h instance_tc0.h instance_chipid.h instance_udp.h instance_dacc.h instance_usart0.h instance_pmc.h instance_piob.h instance_efc1.h instance_rtt.h instance_matrix.h instance_cmcc.h instance_smc.h instance_adc.h instance_efc0.h instance_twi1.h instance_usart1.h instance_wdt.h instance_tc1.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../sam4s/include/pio/: pio_sam4s16b.h pio_sam4sa16c.h pio_sam4sd16b.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s8c.h pio_sam4s8b.h pio_sam4s16c.h pio_sam4sd32b.h pio_sam4sd32c.h
  group sam/utils/cmsis/cm4_nvic_example
    ../../: main.c
  group sam/utils/cmsis/cm4_nvic_example/sam4sd32c_sam4s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_nvic_example/sam4sd32c_sam4s_ek2/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
