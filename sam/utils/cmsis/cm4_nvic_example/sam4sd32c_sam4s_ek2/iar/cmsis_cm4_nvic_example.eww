<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cmsis_cm4_nvic_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\cmsis_cm4_nvic_example_sram.ewp</path>
	</project>
</workspace>
