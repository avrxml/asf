<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cmsis_cm3_cmsis_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\cmsis_cm3_cmsis_example_sram.ewp</path>
	</project>
</workspace>
