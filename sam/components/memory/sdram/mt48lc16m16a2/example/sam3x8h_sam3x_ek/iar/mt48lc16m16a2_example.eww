<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mt48lc16m16a2_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mt48lc16m16a2_example_sram.ewp</path>
	</project>
</workspace>
