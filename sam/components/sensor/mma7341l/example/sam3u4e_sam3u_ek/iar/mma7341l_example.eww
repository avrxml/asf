<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mma7341l_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mma7341l_example_sram.ewp</path>
	</project>
</workspace>
