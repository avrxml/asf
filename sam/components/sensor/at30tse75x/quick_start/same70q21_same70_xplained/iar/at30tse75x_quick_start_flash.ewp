# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../drivers/pmc; ../../../../../../utils; ../../../../../../boards/same70_xplained; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../drivers/twihs; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../utils/fpu; ../../../../../../utils/cmsis/same70/source/templates; ../../../../../../drivers/pio; ../../../../../../drivers/mpu; ../..; ..; ../../../../../../../common/utils; ../../../../../../../common/services/gpio; ../../../../../../../common/services/ioport; ../../../../../../utils/cmsis/same70/include; ../../../../../../../common/services/delay; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/mpu
    ../../../../../../drivers/mpu/: mpu.c mpu.h
  group sam/drivers/twihs
    ../../../../../../drivers/twihs/: twihs.c twihs.h
  group sam/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam/components/sensor/at30tse75x/quick_start/same70q21_same70_xplained
    ../: conf_clock.h conf_board.h conf_at30tse75x.h
  group sam/components/sensor/at30tse75x/quick_start/same70q21_same70_xplained/iar
    ./: asf.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../utils/cmsis/same70/include/: same70q19.h same70n20b.h same70q21b.h same70n19.h same70j20b.h same70q21.h same70q19b.h same70j19b.h same70q20.h same70n21.h same70j19.h same70j20.h same70n19b.h same70j21b.h same70n21b.h same70.h same70n20.h same70q20b.h same70j21.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../utils/cmsis/same70/include/pio/: same70n19.h same70q20.h same70j21.h same70q19.h same70n21b.h same70n21.h same70j20.h same70q21.h same70j20b.h same70n19b.h same70n20b.h same70j21b.h same70q20b.h same70j19.h same70q21b.h same70j19b.h same70q19b.h same70n20.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../utils/cmsis/same70/include/instance/: hsmci.h xdmac.h utmi.h tc3.h supc.h rtc.h pwm1.h pioa.h usart0.h pioc.h piod.h wdt.h dacc.h afec0.h trng.h matrix.h pwm0.h usart1.h qspi.h icm.h usbhs.h pioe.h ssc.h uart0.h usart2.h afec1.h aes.h twihs1.h rtt.h mcan0.h twihs0.h gmac.h uart4.h sdramc.h isi.h spi1.h tc2.h tc0.h pmc.h chipid.h rstc.h i2sc0.h twihs2.h smc.h mcan1.h uart2.h piob.h uart3.h efc.h gpbr.h acc.h uart1.h i2sc1.h tc1.h rswdt.h spi0.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../utils/cmsis/same70/include/component/: rtc.h chipid.h gmac.h icm.h usart.h dacc.h matrix.h utmi.h rstc.h gpbr.h mcan.h acc.h pio.h supc.h wdt.h spi.h i2sc.h hsmci.h usbhs.h isi.h aes.h sdramc.h smc.h rswdt.h trng.h pwm.h uart.h tc.h xdmac.h efc.h afec.h ssc.h pmc.h twihs.h rtt.h qspi.h
  group sam/utils/fpu
    ../../../../../../utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../boards/same70_xplained/: init.c led.h same70_xplained.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/same70
    ../../../../../../../common/services/clock/same70/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
