# IAR project ili9488_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; ILI9488_SPIMODE; ARM_MATH_CM7=true; __SAME70Q21B__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/services/spi/sam_spi; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/same70/source/templates; ../../../../../../drivers/pmc; ../../../../../../utils/cmsis/same70/include; ../../../../../../utils/fpu; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial; ..; ../../../../../../drivers/spi; ../../../../../../drivers/mpu; ../../../../../../../common/utils; ../../..; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../boards/same70_xplained; ../..; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../../common/services/spi; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/pio; ../../../../../../drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili9488_example_flash.bin
  ILINK.IlinkOutputFile: ili9488_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/spi
    ../../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/mpu
    ../../../../../../drivers/mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c uart.h
  group sam/components/display/ili9488
    ../../../: ili9488.c ili9488.h
  group sam/components/display/ili9488/example
    ../../: ili9488_example.c
  group sam/components/display/ili9488/example/same70q21_same70_xplained
    ../: conf_ili9488.h conf_clock.h conf_board.h conf_spi_master.h conf_uart_serial.h
  group sam/components/display/ili9488/example/same70q21_same70_xplained/iar
    ./: asf.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../utils/cmsis/same70/include/: same70q19.h same70q21.h same70q21b.h same70n19.h same70j20b.h same70q19b.h same70j19b.h same70q20.h same70n21.h same70j19.h same70j20.h same70n20b.h same70n19b.h same70j21b.h same70n21b.h same70.h same70n20.h same70q20b.h same70j21.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../utils/cmsis/same70/include/pio/: same70n19.h same70q20.h same70j21.h same70q19.h same70n21b.h same70n21.h same70j19.h same70j20.h same70q21.h same70j20b.h same70n19b.h same70j21b.h same70q20b.h same70q21b.h same70n20b.h same70j19b.h same70q19b.h same70n20.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../utils/cmsis/same70/include/instance/: utmi.h xdmac.h hsmci.h tc3.h supc.h gpbr.h pwm1.h pioa.h usart0.h wdt.h pioc.h piod.h dacc.h afec0.h trng.h matrix.h rtc.h pwm0.h usart1.h qspi.h piob.h usbhs.h pioe.h ssc.h uart0.h usart2.h afec1.h aes.h twihs1.h rtt.h mcan0.h twihs0.h gmac.h uart4.h sdramc.h isi.h spi1.h tc2.h tc0.h pmc.h chipid.h rstc.h i2sc0.h twihs2.h smc.h mcan1.h uart2.h icm.h uart3.h efc.h acc.h uart1.h i2sc1.h tc1.h rswdt.h spi0.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../utils/cmsis/same70/include/component/: rtc.h chipid.h gmac.h usart.h dacc.h matrix.h utmi.h rstc.h mcan.h acc.h pio.h supc.h wdt.h spi.h i2sc.h hsmci.h usbhs.h isi.h aes.h sdramc.h smc.h rswdt.h trng.h pwm.h uart.h tc.h xdmac.h efc.h gpbr.h afec.h ssc.h pmc.h twihs.h rtt.h qspi.h icm.h
  group sam/utils/fpu
    ../../../../../../utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../boards/same70_xplained/: init.c led.h same70_xplained.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/same70
    ../../../../../../../common/services/clock/same70/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
