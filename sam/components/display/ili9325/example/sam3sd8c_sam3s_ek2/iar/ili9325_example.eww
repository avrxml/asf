<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ili9325_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ili9325_example_sram.ewp</path>
	</project>
</workspace>
