# IAR project c42364a_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../..; ../../../../../../../common/services/serial/sam_uart; ../../../../../../utils/preprocessor; ..; ../../../../../../utils/cmsis/sam4cp/source/templates; ../../../../../../utils/cmsis/sam4cp/include; ../../../../../../../common/services/serial; ../../../../../../drivers/supc; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../../boards/sam4cp16bmb; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../drivers/uart; ../../../../../../utils; ../../..; ../../../../../../drivers/slcdc; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/pmc; ../../../../../../drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: c42364a_example_flash.bin
  ILINK.IlinkOutputFile: c42364a_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/components/display/c42364a
    ../../../: c42364a_slcdc.c c42364a_font.h c42364a_segmap.h c42364a.h
  group sam/components/display/c42364a/example
    ../../: c42364a_example.c
  group sam/components/display/c42364a/example/sam4cp16b_sam4cp16bmb
    ../: conf_c42364a_slcdc.h conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_slcdc.h
  group sam/components/display/c42364a/example/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group sam/boards/sam4cp16bmb
    ../../../../../../boards/sam4cp16bmb/: init.c led.h sam4cp16bmb.h
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/supc
    ../../../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/slcdc
    ../../../../../../drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../utils/cmsis/sam4cp/include/: system_sam4cp.h sam4cp_1.h sam4cp.h sam4cp16b_0.h sam4cp_0.h sam4cp16b_1.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../utils/cmsis/sam4cp/include/component/: component_cmcc.h component_pwm.h component_rstc.h component_rtc.h component_adc.h component_trng.h component_pio.h component_uart.h component_matrix.h component_usart.h component_smc.h component_ipc.h component_spi.h component_aes.h component_gpbr.h component_twi.h component_efc.h component_pmc.h component_supc.h component_pdc.h component_chipid.h component_slcdc.h component_tc.h component_icm.h component_wdt.h component_rswdt.h component_rtt.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../utils/cmsis/sam4cp/include/instance/: instance_wdt.h instance_aes.h instance_twi1.h instance_trng.h instance_adc.h instance_cmcc0.h instance_tc1.h instance_smc0.h instance_pmc.h instance_gpbr.h instance_rtt.h instance_spi0.h instance_rstc.h instance_matrix0.h instance_rswdt.h instance_pioa.h instance_tc0.h instance_matrix1.h instance_icm.h instance_piob.h instance_cmcc1.h instance_uart1.h instance_spi1.h instance_ipc0.h instance_usart3.h instance_usart1.h instance_usart4.h instance_rtc.h instance_chipid.h instance_pioc.h instance_efc.h instance_usart2.h instance_slcdc.h instance_ipc1.h instance_usart0.h instance_smc1.h instance_twi0.h instance_uart0.h instance_pwm.h instance_supc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4cp
    ../../../../../../../common/services/clock/sam4cp/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
