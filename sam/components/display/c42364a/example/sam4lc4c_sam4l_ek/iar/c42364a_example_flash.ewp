# IAR project c42364a_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../..; ../../../../../../../common/services/serial/sam_uart; ../../../../../../drivers/lcdca; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../drivers/pdca; ../../../../../../utils/cmsis/sam4l/include; ../../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../../common/services/serial; ..; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../../boards/sam4l_ek; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/delay; ../../../../../../utils; ../../..; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../drivers/flashcalw; ../../../../../../../common/services/ioport; ../../../../../../drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: c42364a_example_flash.bin
  ILINK.IlinkOutputFile: c42364a_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/components/display/c42364a
    ../../../: c42364a.c c42364a.h
  group sam/components/display/c42364a/example
    ../../: c42364a_example.c
  group sam/components/display/c42364a/example/sam4lc4c_sam4l_ek
    ../: conf_sleepmgr.h conf_board.h conf_lcdca.h conf_uart_serial.h conf_c42364a.h conf_clock.h
  group sam/components/display/c42364a/example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group sam/drivers/bpm
    ../../../../../../drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/lcdca
    ../../../../../../drivers/lcdca/: lcdca.c lcdca.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pdca
    ../../../../../../drivers/pdca/: pdca.c pdca.h
  group sam/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam/boards/sam4l_ek
    ../../../../../../boards/sam4l_ek/: board_monitor.c init.c led.h board_monitor.h sam4l_ek.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h genclk.h pll.h dfll.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c genclk.h osc.h sysclk.h dfll.h pll.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
