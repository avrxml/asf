<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hx8347a_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\hx8347a_example_sram.ewp</path>
	</project>
</workspace>
