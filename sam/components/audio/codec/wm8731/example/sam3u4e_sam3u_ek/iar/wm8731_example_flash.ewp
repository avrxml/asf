# IAR project wm8731_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../utils/cmsis/sam3u/source/templates; ../../../../../../../utils/preprocessor; ../..; ../../../../../../../drivers/pmc; ..; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/serial; ../../../../../../../../common/utils; ../../../../../../../../common/services/clock; ../../../../../../../boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../boards/sam3u_ek; ../../../../../../../drivers/dmac; ../../../../../../../utils/cmsis/sam3u/include; ../../../../../../../drivers/ebi/smc; ../../../../../../../../common/services/twi; ../../../../../../../drivers/uart; ../../../../../../../utils; ../../../../../../../drivers/usart; ../../../../../../../utils/header_files; ../../../../../../../../common/boards; ../../..; ../../../../../../../../common/services/ioport; ../../../../../../../drivers/pio; ../../../../../../../drivers/ssc; ../../../../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wm8731_example_flash.bin
  ILINK.IlinkOutputFile: wm8731_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pio
    ../../../../../../../drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/ebi/smc
    ../../../../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/ssc
    ../../../../../../../drivers/ssc/: ssc.c ssc.h
  group sam/drivers/uart
    ../../../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/twi
    ../../../../../../../drivers/twi/: twi.c twi.h
  group sam/drivers/pmc
    ../../../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/dmac
    ../../../../../../../drivers/dmac/: dmac.c dmac.h
  group sam/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group sam/components/audio/codec/wm8731
    ../../../: wm8731.c wm8731.h
  group sam/components/audio/codec/wm8731/example
    ../../: xmodem.c wm8731_example.c xmodem.h
  group sam/components/audio/codec/wm8731/example/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_wm8731.h conf_board.h
  group sam/components/audio/codec/wm8731/example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group sam/boards/sam3u_ek
    ../../../../../../../boards/sam3u_ek/: init.c led.c led.h sam3u_ek.h
  group sam/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c exceptions.h system_sam3u.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../../utils/cmsis/sam3u/include/: sam3u2c.h sam3u.h sam3u4c.h sam3u2e.h sam3u4e.h sam3u1c.h sam3u1e.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../../utils/cmsis/sam3u/include/instance/: instance_pioa.h instance_usart1.h instance_chipid.h instance_usart3.h instance_adc12b.h instance_gpbr.h instance_twi1.h instance_adc.h instance_spi.h instance_usart0.h instance_hsmci.h instance_usart2.h instance_dmac.h instance_pmc.h instance_ssc.h instance_wdt.h instance_pwm.h instance_rstc.h instance_piob.h instance_supc.h instance_efc0.h instance_rtc.h instance_udphs.h instance_pioc.h instance_efc1.h instance_smc.h instance_uart.h instance_tc0.h instance_matrix.h instance_rtt.h instance_twi0.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../../utils/cmsis/sam3u/include/component/: component_rtt.h component_smc.h component_ssc.h component_efc.h component_gpbr.h component_supc.h component_spi.h component_wdt.h component_dmac.h component_matrix.h component_chipid.h component_adc12b.h component_rstc.h component_twi.h component_pdc.h component_usart.h component_hsmci.h component_uart.h component_adc.h component_udphs.h component_pwm.h component_rtc.h component_pio.h component_pmc.h component_tc.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../../utils/cmsis/sam3u/include/pio/: pio_sam3u4c.h pio_sam3u4e.h pio_sam3u2e.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u2c.h
  group sam/utils/preprocessor
    ../../../../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam3u
    ../../../../../../../../common/services/clock/sam3u/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
