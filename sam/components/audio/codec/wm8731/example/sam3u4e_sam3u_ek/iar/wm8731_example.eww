<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wm8731_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\wm8731_example_sram.ewp</path>
	</project>
</workspace>
