# IAR project wm8731_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../../../../../../utils/header_files; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/pmc; ../../../../../../../boards/sam3x_ek; ../../../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../../../common/components/memory/eeprom/at24cxx; ../..; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/serial; ../../../../../../../utils/cmsis/sam3x/include; ../../../../../../../../common/utils; ../../../../../../../../common/services/clock; ../../../../../../../boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/dmac; ../../../../../../../../common/services/twi; ../../../../../../../../common/services/delay; ../../../../../../../drivers/uart; ../../../../../../../utils; ../../../../../../../drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../common/boards; ../../..; ../../../../../../../../common/services/ioport; ../../../../../../../drivers/pio; ../../../../../../../drivers/ssc; ../../../../../../../drivers/twi; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wm8731_unit_tests_flash.bin
  ILINK.IlinkOutputFile: wm8731_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/ssc
    ../../../../../../../drivers/ssc/: ssc.c ssc.h
  group sam/drivers/uart
    ../../../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/dmac
    ../../../../../../../drivers/dmac/: dmac.c dmac.h
  group sam/drivers/twi
    ../../../../../../../drivers/twi/: twi.c twi.h
  group sam/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c system_sam3x.h exceptions.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../../utils/cmsis/sam3x/include/: sam3x8c.h sam3x8h.h sam3x8e.h sam3x4c.h sam3a4c.h sam3xa.h sam3x4e.h sam3a8c.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../../utils/cmsis/sam3x/include/component/: component_hsmci.h component_rstc.h component_dmac.h component_dacc.h component_pio.h component_can.h component_pdc.h component_gpbr.h component_uart.h component_sdramc.h component_usart.h component_spi.h component_rtt.h component_chipid.h component_trng.h component_twi.h component_tc.h component_wdt.h component_uotghs.h component_ssc.h component_pwm.h component_rtc.h component_emac.h component_pmc.h component_supc.h component_smc.h component_matrix.h component_efc.h component_adc.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../../utils/cmsis/sam3x/include/instance/: instance_pioe.h instance_pmc.h instance_usart0.h instance_hsmci.h instance_pioc.h instance_rtc.h instance_uart.h instance_dacc.h instance_usart2.h instance_spi1.h instance_usart1.h instance_piob.h instance_tc0.h instance_tc2.h instance_efc1.h instance_uotghs.h instance_smc.h instance_supc.h instance_piof.h instance_spi0.h instance_usart3.h instance_piod.h instance_twi1.h instance_sdramc.h instance_adc.h instance_can1.h instance_emac.h instance_pwm.h instance_gpbr.h instance_tc1.h instance_wdt.h instance_ssc.h instance_rtt.h instance_matrix.h instance_efc0.h instance_rstc.h instance_twi0.h instance_pioa.h instance_trng.h instance_can0.h instance_chipid.h instance_dmac.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../../utils/cmsis/sam3x/include/pio/: pio_sam3x8e.h pio_sam3a8c.h pio_sam3a4c.h pio_sam3x4e.h pio_sam3x4c.h pio_sam3x8c.h pio_sam3x8h.h
  group sam/utils/preprocessor
    ../../../../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam/components/audio/codec/wm8731
    ../../../: wm8731.c wm8731.h
  group sam/components/audio/codec/wm8731/unit_tests
    ../../: unit_tests.c
  group sam/components/audio/codec/wm8731/unit_tests/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_clock.h conf_wm8731.h conf_board.h conf_test.h
  group sam/components/audio/codec/wm8731/unit_tests/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group sam/boards/sam3x_ek
    ../../../../../../../boards/sam3x_ek/: led.c init.c led.h sam3x_ek.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../../../../common/services/clock/sam3x/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/components/memory/eeprom/at24cxx
    ../../../../../../../../common/components/memory/eeprom/at24cxx/: at24cxx.c at24cxx.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
