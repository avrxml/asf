# IAR project wm8904_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../../utils/header_files; ..; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/pmc; ../../..; ../..; ../../../../../../../utils/fpu; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/serial; ../../../../../../../drivers/mpu; ../../../../../../../../common/utils; ../../../../../../../utils/cmsis/samv71/source/templates; ../../../../../../../boards/samv71_xplained_ultra; ../../../../../../../../common/services/clock; ../../../../../../../boards; ../../../../../../../drivers/twihs; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../common/services/twi; ../../../../../../../../common/services/delay; ../../../../../../../drivers/uart; ../../../../../../../utils; ../../../../../../../drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../common/boards; ../../../../../../../../common/services/ioport; ../../../../../../../drivers/pio; ../../../../../../../drivers/xdmac; ../../../../../../../drivers/ssc; ../../../../../../../utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wm8904_example_flash.bin
  ILINK.IlinkOutputFile: wm8904_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/samv71_xplained_ultra
    ../../../../../../../boards/samv71_xplained_ultra/: init.c samv71_xplained_ultra.h led.h
  group sam/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/mpu
    ../../../../../../../drivers/mpu/: mpu.c mpu.h
  group sam/drivers/xdmac
    ../../../../../../../drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/uart
    ../../../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/ssc
    ../../../../../../../drivers/ssc/: ssc.c ssc.h
  group sam/drivers/twihs
    ../../../../../../../drivers/twihs/: twihs.c twihs.h
  group sam/drivers/pmc
    ../../../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/components/audio/codec/wm8904
    ../../../: wm8904.c wm8904.h
  group sam/components/audio/codec/wm8904/example
    ../../: wm8904_example.c
  group sam/components/audio/codec/wm8904/example/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_wm8904.h conf_sleepmgr.h
  group sam/components/audio/codec/wm8904/example/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group sam/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../../utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../../utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../../utils/cmsis/samv71/include/: samv71j19.h samv71j21.h samv71n20b.h samv71n20.h samv71n19.h samv71q19b.h samv71n21.h samv71q20.h samv71j20.h samv71q19.h samv71q20b.h samv71n21b.h samv71.h samv71j20b.h samv71j21b.h samv71q21b.h samv71q21.h samv71n19b.h samv71j19b.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../../utils/cmsis/samv71/include/instance/: hsmci.h pioc.h sdramc.h pwm0.h usart0.h qspi.h mlb.h utmi.h mcan1.h efc.h chipid.h ssc.h supc.h rtt.h spi0.h afec0.h piod.h uart0.h rstc.h uart4.h trng.h xdmac.h tc1.h tc3.h mcan0.h dacc.h gpbr.h acc.h spi1.h uart2.h matrix.h rtc.h pioe.h uart1.h tc0.h tc2.h twihs2.h pmc.h gmac.h usart1.h uart3.h pioa.h twihs0.h rswdt.h isi.h pwm1.h usbhs.h aes.h i2sc0.h wdt.h piob.h icm.h twihs1.h usart2.h smc.h i2sc1.h afec1.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../../utils/cmsis/samv71/include/pio/: samv71n19b.h samv71j21.h samv71j19.h samv71q20.h samv71q21.h samv71j19b.h samv71n21b.h samv71q21b.h samv71j20b.h samv71n19.h samv71q19.h samv71j21b.h samv71q20b.h samv71n20b.h samv71j20.h samv71n20.h samv71n21.h samv71q19b.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../../utils/cmsis/samv71/include/component/: supc.h utmi.h mlb.h gmac.h trng.h twihs.h ssc.h rtt.h matrix.h pwm.h tc.h pio.h spi.h aes.h chipid.h rstc.h usart.h icm.h xdmac.h wdt.h smc.h i2sc.h afec.h efc.h dacc.h pmc.h hsmci.h usbhs.h gpbr.h rswdt.h acc.h rtc.h sdramc.h isi.h qspi.h mcan.h uart.h
  group sam/utils/preprocessor
    ../../../../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../utils/fpu/: fpu.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/samv71
    ../../../../../../../../common/services/clock/samv71/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../../common/services/twi/: twihs_master.h twihs_slave.h
  group common/services/twi/sam_twihs
    ../../../../../../../../common/services/twi/sam_twihs/: twihs_slave.h twihs_master.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
