# IAR project ov7740_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; OV7740_TWIHS_SUPPORT=true; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAMV71Q21B__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../../drivers/isi; ../../../../../../utils/preprocessor; ../../../../../../drivers/pmc; ../../../../../../utils/fpu; ../../../../../../../common/services/serial; ../..; ../../../../../../drivers/mpu; ../../../../../../../common/utils; ../../../../../../utils/cmsis/samv71/source/templates; ../../../../../../boards/samv71_xplained_ultra; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../drivers/twihs; ../../../../../../../common/utils/stdio/stdio_serial; ../../..; ../../../../../../../common/services/gpio; ../../../../../../../common/services/delay; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/pio; ..; ../../../../../../utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ov7740_unit_tests_flash.bin
  ILINK.IlinkOutputFile: ov7740_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samv71
    ../../../../../../../common/services/clock/samv71/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group sam/components/cmos_image_sensor/ov7740
    ../../../: ov7740_1.c ov7740_table_registers.c ov7740.h
  group sam/components/cmos_image_sensor/ov7740/unit_tests
    ../../: unit_tests_1.c
  group sam/components/cmos_image_sensor/ov7740/unit_tests/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_board.h conf_test.h conf_clock.h
  group sam/components/cmos_image_sensor/ov7740/unit_tests/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/mpu
    ../../../../../../drivers/mpu/: mpu.c mpu.h
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/twihs
    ../../../../../../drivers/twihs/: twihs.c twihs.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/isi
    ../../../../../../drivers/isi/: isi.c isi.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../utils/cmsis/samv71/include/: samv71j20.h samv71q20.h samv71n19b.h samv71j19.h samv71j20b.h samv71n19.h samv71n20.h samv71q21b.h samv71j21.h samv71n20b.h samv71q19b.h samv71j19b.h samv71n21.h samv71n21b.h samv71q19.h samv71q21.h samv71q20b.h samv71j21b.h samv71.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../utils/cmsis/samv71/include/instance/: sdramc.h matrix.h spi0.h twihs1.h efc.h qspi.h dacc.h rstc.h afec1.h gpbr.h smc.h ssc.h pwm1.h pmc.h usart2.h mlb.h aes.h wdt.h acc.h i2sc1.h gmac.h hsmci.h supc.h xdmac.h tc3.h mcan0.h rtt.h pwm0.h pioe.h usbhs.h uart4.h tc0.h chipid.h uart1.h trng.h usart0.h uart3.h pioc.h pioa.h mcan1.h spi1.h piod.h i2sc0.h isi.h rswdt.h twihs0.h uart0.h rtc.h tc1.h usart1.h uart2.h tc2.h piob.h afec0.h twihs2.h icm.h utmi.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../utils/cmsis/samv71/include/pio/: samv71j19.h samv71n19b.h samv71q21.h samv71n20b.h samv71j20.h samv71j21b.h samv71q19.h samv71q20.h samv71n19.h samv71q19b.h samv71j19b.h samv71q20b.h samv71q21b.h samv71j20b.h samv71n20.h samv71n21b.h samv71n21.h samv71j21.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../utils/cmsis/samv71/include/component/: qspi.h efc.h mlb.h smc.h rtc.h afec.h matrix.h sdramc.h utmi.h hsmci.h xdmac.h aes.h rtt.h gpbr.h acc.h trng.h i2sc.h dacc.h usart.h gmac.h pio.h chipid.h supc.h spi.h wdt.h mcan.h ssc.h tc.h twihs.h pwm.h icm.h uart.h usbhs.h pmc.h rswdt.h rstc.h isi.h
  group sam/utils/fpu
    ../../../../../../utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
