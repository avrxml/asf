<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\re200b_pir_motion_detection_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\re200b_pir_motion_detection_example_sram.ewp</path>
	</project>
</workspace>
