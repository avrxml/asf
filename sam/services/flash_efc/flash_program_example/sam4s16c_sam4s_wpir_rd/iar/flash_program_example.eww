<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flash_program_example_flash.ewp</path>
	</project>
</workspace>
