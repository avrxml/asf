<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flash_program_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\flash_program_example_sram.ewp</path>
	</project>
</workspace>
