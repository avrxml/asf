# IAR project flash_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMP16C_0 Atmel ATSAM4CMP16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4CMP16C_0__; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial; ../../../../../drivers/uart; ../../../../../utils; ../..; ../../../../../utils/cmsis/sam4cm/include; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../boards/sam4cmp_db; ../../../../../drivers/efc; ../../../../../../common/services/clock; ../../../../../utils/cmsis/sam4cm/source/templates; ..; ../../..; ../../../../../boards; ../../../../../../common/utils; ../../../../../utils/header_files; ../../../../../drivers/pmc; ../../../../../../common/services/ioport; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flash_unit_tests_flash.bin
  ILINK.IlinkOutputFile: flash_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4cm/iar/sam4cmp16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/services/flash_efc
    ../../../: flash_efc.c flash_efc.h
  group sam/services/flash_efc/unit_tests
    ../../: unit_tests.c
  group sam/services/flash_efc/unit_tests/sam4cmp16c_sam4cmp_db
    ../: conf_uart_serial.h conf_test.h conf_clock.h conf_board.h
  group sam/services/flash_efc/unit_tests/sam4cmp16c_sam4cmp_db/iar
    ./: asf.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../utils/cmsis/sam4cm/include/: sam4cm.h sam4cms16c_1.h sam4cms8c_1.h sam4cms8c_0.h sam4cmp16c_0.h sam4cms16c_0.h sam4cmp16c_1.h sam4cmp8c_0.h system_sam4cm.h sam4cmp8c_1.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../utils/cmsis/sam4cm/include/component/: gpbr.h aes.h pio.h pdc.h smc.h icm.h rtc.h matrix.h pwm.h slcdc.h cmcc.h spi.h uart.h tc.h pmc.h rtt.h rswdt.h efc.h trng.h wdt.h twi.h ipc.h chipid.h usart.h supc.h adc.h rstc.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../utils/cmsis/sam4cm/include/instance/: usart0.h efc.h spi1.h rswdt.h pioa.h supc.h usart2.h twi1.h rstc.h cmcc0.h slcdc.h rtc.h ipc0.h twi0.h pmc.h trng.h cmcc1.h matrix1.h rtt.h tc1.h gpbr.h icm.h adc.h uart1.h piob.h ipc1.h wdt.h aes.h uart0.h spi0.h matrix0.h pwm.h chipid.h usart1.h smc0.h usart3.h smc1.h tc0.h pioc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cms16c.h sam4cmp8c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4cmp_db
    ../../../../../boards/sam4cmp_db/: init.c led.h sam4cmp_db.h
