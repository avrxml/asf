# IAR project unique_id_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ../../../../../drivers/efc; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../..; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/sam4e/include; ../../../../../../common/services/gpio; ..; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../drivers/pio; ../../../../../boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: unique_id_example_flash.bin
  ILINK.IlinkOutputFile: unique_id_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../utils/cmsis/sam4e/include/: sam4e.h sam4e16c.h sam4e8e.h sam4e8c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../utils/cmsis/sam4e/include/instance/: hsmci.h wdt.h tc1.h cmcc.h chipid.h rswdt.h twi0.h pmc.h crccu.h pioc.h udp.h pwm.h efc.h acc.h rtt.h matrix.h gpbr.h aes.h spi.h afec0.h can1.h usart0.h piob.h uart1.h afec1.h pioe.h piod.h supc.h rtc.h dmac.h can0.h usart1.h gmac.h dacc.h tc2.h uart0.h tc0.h smc.h twi1.h pioa.h rstc.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../utils/cmsis/sam4e/include/component/: cmcc.h supc.h rstc.h matrix.h pdc.h usart.h wdt.h gpbr.h rtc.h efc.h dacc.h rtt.h acc.h smc.h udp.h aes.h dmac.h hsmci.h chipid.h afec.h pmc.h spi.h can.h rswdt.h gmac.h tc.h uart.h crccu.h pio.h twi.h pwm.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e8c.h sam4e8e.h sam4e16c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c sam4e_ek.h led.h
  group sam/services/flash_efc
    ../../../: flash_efc.c flash_efc.h
  group sam/services/flash_efc/flash_read_unique_id_example
    ../../: flash_read_unique_id_example.c
  group sam/services/flash_efc/flash_read_unique_id_example/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/services/flash_efc/flash_read_unique_id_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c sysclk.h genclk.h pll.h osc.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
