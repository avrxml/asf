# IAR project unique_id_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ../../../../../drivers/flexcom; ../../../../../boards/samg55_xplained_pro; ../../../../../drivers/efc; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../..; ../../../../../drivers/supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../utils/cmsis/samg/samg55/include; ..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils/cmsis/samg/samg55/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: unique_id_example_flash.bin
  ILINK.IlinkOutputFile: unique_id_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../utils/cmsis/samg/samg55/include/: samg55g18.h samg55j19.h samg55.h system_samg55.h samg55g19.h samg55j18.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../utils/cmsis/samg/samg55/include/instance/: tc0.h piob.h chipid.h flexcom2.h flexcom0.h usart0.h wdt.h usart6.h i2sc1.h pdmic1.h supc.h rstc.h spi1.h pmc.h rtt.h gpbr.h flexcom4.h flexcom3.h cmcc.h efc.h i2sc0.h crccu.h pdmic0.h twi0.h spi4.h flexcom7.h flexcom1.h spi0.h pioa.h flexcom5.h usart2.h usart5.h rtc.h spi2.h spi5.h twi4.h twi6.h adc.h spi7.h mem2mem.h twi2.h twi1.h usart4.h tc1.h usart1.h usart3.h matrix.h spi3.h usart7.h udp.h flexcom6.h twi5.h twi7.h spi6.h uhp.h twi3.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../utils/cmsis/samg/samg55/include/component/: flexcom.h gpbr.h wdt.h usart.h rtc.h udp.h adc.h pio.h cmcc.h crccu.h mem2mem.h rstc.h i2sc.h supc.h matrix.h uhp.h chipid.h tc.h pmc.h pdmic.h pdc.h efc.h rtt.h spi.h twi.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55g18.h samg55j19.h samg55n19.h samg55j18.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/services/flash_efc
    ../../../: flash_efc.c flash_efc.h
  group sam/services/flash_efc/flash_read_unique_id_example
    ../../: flash_read_unique_id_example.c
  group sam/services/flash_efc/flash_read_unique_id_example/samg55j19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h
  group sam/services/flash_efc/flash_read_unique_id_example/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/flexcom
    ../../../../../drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/supc
    ../../../../../drivers/supc/: supc.c supc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
