<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\unique_id_example_flash.ewp</path>
	</project>
</workspace>
