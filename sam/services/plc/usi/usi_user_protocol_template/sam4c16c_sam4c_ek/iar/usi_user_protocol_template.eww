<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usi_user_protocol_template_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\usi_user_protocol_template_sram.ewp</path>
	</project>
</workspace>
