<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\lin_mngt_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\lin_mngt_example_sram.ewp</path>
	</project>
</workspace>
