# IAR project resistive_touch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../../../common/services/spi/sam_spi; ../../../../../utils/preprocessor; ../../../../../drivers/pio; ../..; ../../../../../drivers/ebi/smc; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3s8/source/templates; ../../../../../drivers/spi; ../../../../../../common/utils; ../../../../../components/resistive_touch/ads7843; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../components/display/aat31xx; ../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../boards/sam3s_ek2; ../../../../../../common/services/gpio; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../..; ../../../../../components/display/ili9325; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../utils/cmsis/sam3s8/include; ../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: resistive_touch_example_flash.bin
  ILINK.IlinkOutputFile: resistive_touch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/ebi/smc
    ../../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/services/resistive_touch
    ../../../: rtouch.c rtouch.h rtouch_ads7843.h
  group sam/services/resistive_touch/example
    ../../: rtouch_calibrate.c ads7843_example.c rtouch_calibrate.h
  group sam/services/resistive_touch/example/sam3sd8c_sam3s_ek2
    ../: resistive_touch_board.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_aat31xx.h conf_ads7843.h conf_ili9325.h
  group sam/services/resistive_touch/example/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: led.c init.c led.h sam3s_ek2.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c system_sam3sd8.h exceptions.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../utils/cmsis/sam3s8/include/: sam3sd8b.h sam3s8c.h sam3s8b.h sam3s8.h sam3sd8c.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../utils/cmsis/sam3s8/include/pio/: pio_sam3sd8c.h pio_sam3sd8b.h pio_sam3s8c.h pio_sam3s8b.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../utils/cmsis/sam3s8/include/instance/: instance_uart1.h instance_spi.h instance_dacc.h instance_wdt.h instance_twi1.h instance_tc1.h instance_smc.h instance_ssc.h instance_chipid.h instance_udp.h instance_gpbr.h instance_hsmci.h instance_rtt.h instance_tc0.h instance_matrix.h instance_adc.h instance_supc.h instance_pioa.h instance_efc.h instance_rstc.h instance_twi0.h instance_usart1.h instance_pwm.h instance_rtc.h instance_pioc.h instance_uart0.h instance_piob.h instance_acc.h instance_usart2.h instance_usart0.h instance_pmc.h instance_crccu.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../utils/cmsis/sam3s8/include/component/: component_dacc.h component_pdc.h component_rtt.h component_acc.h component_matrix.h component_smc.h component_efc.h component_pmc.h component_pwm.h component_supc.h component_crccu.h component_gpbr.h component_pio.h component_hsmci.h component_rstc.h component_uart.h component_twi.h component_spi.h component_adc.h component_ssc.h component_tc.h component_udp.h component_chipid.h component_rtc.h component_wdt.h component_usart.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/components/display/aat31xx
    ../../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/display/ili9325
    ../../../../../components/display/ili9325/: ili9325.c ili9325.h
  group sam/components/resistive_touch/ads7843
    ../../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
