# IAR project resistive_touch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../../../common/services/spi/sam_spi; ..; ../../../../../utils/preprocessor; ../../../../../drivers/pio; ../../../../../boards/sam3x_ek; ../..; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../../drivers/ebi/smc; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/include; ../../../../../drivers/spi; ../../../../../../common/utils; ../../../../../components/resistive_touch/ads7843; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../components/display/aat31xx; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../..; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../components/display/hx8347a; ../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: resistive_touch_example_flash.bin
  ILINK.IlinkOutputFile: resistive_touch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c system_sam3x.h exceptions.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../utils/cmsis/sam3x/include/: sam3xa.h sam3a4c.h sam3x4c.h sam3x8c.h sam3a8c.h sam3x8e.h sam3x8h.h sam3x4e.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../utils/cmsis/sam3x/include/instance/: instance_hsmci.h instance_usart0.h instance_rstc.h instance_can0.h instance_matrix.h instance_pioe.h instance_piof.h instance_smc.h instance_piob.h instance_chipid.h instance_efc1.h instance_adc.h instance_dmac.h instance_piod.h instance_spi1.h instance_usart3.h instance_tc0.h instance_usart2.h instance_uart.h instance_tc2.h instance_wdt.h instance_trng.h instance_supc.h instance_twi1.h instance_efc0.h instance_rtc.h instance_pwm.h instance_sdramc.h instance_tc1.h instance_dacc.h instance_can1.h instance_rtt.h instance_emac.h instance_usart1.h instance_gpbr.h instance_twi0.h instance_ssc.h instance_uotghs.h instance_spi0.h instance_pioc.h instance_pmc.h instance_pioa.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3x8h.h pio_sam3x8e.h pio_sam3x8c.h pio_sam3x4c.h pio_sam3x4e.h pio_sam3a4c.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../utils/cmsis/sam3x/include/component/: component_twi.h component_smc.h component_uart.h component_spi.h component_efc.h component_adc.h component_supc.h component_pdc.h component_can.h component_tc.h component_wdt.h component_ssc.h component_rstc.h component_chipid.h component_pwm.h component_usart.h component_matrix.h component_dmac.h component_trng.h component_hsmci.h component_uotghs.h component_gpbr.h component_pio.h component_rtt.h component_pmc.h component_sdramc.h component_emac.h component_rtc.h component_dacc.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/ebi/smc
    ../../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c led.c led.h sam3x_ek.h
  group sam/services/resistive_touch
    ../../../: rtouch.c rtouch.h rtouch_ads7843.h
  group sam/services/resistive_touch/example
    ../../: rtouch_calibrate.c ads7843_example.c rtouch_calibrate.h
  group sam/services/resistive_touch/example/sam3x8h_sam3x_ek
    ../: resistive_touch_board.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_hx8347a.h conf_aat31xx.h conf_ads7843.h
  group sam/services/resistive_touch/example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group sam/components/display/aat31xx
    ../../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/display/hx8347a
    ../../../../../components/display/hx8347a/: hx8347a.c hx8347a.h
  group sam/components/resistive_touch/ads7843
    ../../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
