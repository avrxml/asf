<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt_unit_tests_flash.ewp</path>
	</project>
</workspace>
