<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt_example_flash.ewp</path>
	</project>
</workspace>
