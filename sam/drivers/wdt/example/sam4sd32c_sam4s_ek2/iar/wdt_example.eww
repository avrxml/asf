<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\wdt_example_sram.ewp</path>
	</project>
</workspace>
