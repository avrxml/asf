<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twim_twim_example_flash.ewp</path>
	</project>
</workspace>
