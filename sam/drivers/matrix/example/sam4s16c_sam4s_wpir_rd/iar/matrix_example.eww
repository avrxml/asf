<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\matrix_example_flash.ewp</path>
	</project>
</workspace>
