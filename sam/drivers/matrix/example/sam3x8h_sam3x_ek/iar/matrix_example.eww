<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\matrix_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\matrix_example_sram.ewp</path>
	</project>
</workspace>
