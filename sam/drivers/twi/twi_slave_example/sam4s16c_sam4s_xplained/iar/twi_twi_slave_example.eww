<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twi_twi_slave_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\twi_twi_slave_example_sram.ewp</path>
	</project>
</workspace>
