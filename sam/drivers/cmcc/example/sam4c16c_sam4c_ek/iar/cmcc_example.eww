<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cmcc_example_flash.ewp</path>
	</project>
</workspace>
