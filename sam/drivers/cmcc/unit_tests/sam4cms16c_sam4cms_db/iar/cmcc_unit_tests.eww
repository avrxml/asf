<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cmcc_unit_tests_flash.ewp</path>
	</project>
</workspace>
