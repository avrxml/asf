<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mcan_quick_start_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mcan_quick_start_sram.ewp</path>
	</project>
</workspace>
