<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\parc_example_flash.ewp</path>
	</project>
</workspace>
