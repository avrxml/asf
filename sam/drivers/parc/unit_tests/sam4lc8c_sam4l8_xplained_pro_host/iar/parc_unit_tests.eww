<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\parc_unit_tests_flash.ewp</path>
	</project>
</workspace>
