<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashcalw_unit_tests_flash.ewp</path>
	</project>
</workspace>
