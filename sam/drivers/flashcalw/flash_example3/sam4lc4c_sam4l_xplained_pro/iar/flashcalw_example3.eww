<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashcalw_example3_flash.ewp</path>
	</project>
</workspace>
