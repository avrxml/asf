<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashcalw_example1_flash.ewp</path>
	</project>
</workspace>
