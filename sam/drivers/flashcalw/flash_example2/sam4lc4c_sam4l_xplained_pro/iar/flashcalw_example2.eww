<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashcalw_example2_flash.ewp</path>
	</project>
</workspace>
