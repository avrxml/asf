<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\iisc_unit_tests_flash.ewp</path>
	</project>
</workspace>
