<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_example_flash.ewp</path>
	</project>
</workspace>
