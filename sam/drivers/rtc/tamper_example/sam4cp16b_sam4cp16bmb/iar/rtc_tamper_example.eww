<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_tamper_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\rtc_tamper_example_sram.ewp</path>
	</project>
</workspace>
