<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ipc_example_core0_flash.ewp</path>
	</project>
</workspace>
