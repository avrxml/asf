# IAR project ipc_example_core0_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../rstc; ../../../../../../utils/preprocessor; ../../conf_src/common; ../../../../../../utils/cmsis/sam4cp/source/templates; ../../conf_src/core0; ../../../../../../utils/cmsis/sam4cp/include; ../../../../../../../common/services/serial; ../../../../../supc; ../../../../../../../common/utils; ../../../../../../boards/sam4cp16bmb; ../../../..; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/delay; ../../../../../uart; ../../../../../../utils; ../../../../../usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../pmc; ..; ../../../src_core0; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ipc_example_core0_flash.bin
  ILINK.IlinkOutputFile: ipc_example_core0_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/ipc
    ../../../../: ipc.c ipc.h
  group sam/drivers/ipc/example/src_core0
    ../../../src_core0/: ipc_example_core0.c
  group sam/drivers/ipc/example/sam4cp16b_sam4cp16bmb/conf_src/common
    ../../conf_src/common/: conf_clock.h conf_board.h conf_example.h
  group sam/drivers/ipc/example/sam4cp16b_sam4cp16bmb/conf_src/core0
    ../../conf_src/core0/: conf_uart_serial.h
  group sam/drivers/ipc/example/sam4cp16b_sam4cp16bmb/project_core0/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../../pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../usart/: usart.c usart.h
  group sam/drivers/rstc
    ../../../../../rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../../rstc/example1/: rstc_example1.h
  group sam/drivers/supc
    ../../../../../supc/: supc.c supc.h
  group sam/boards/sam4cp16bmb
    ../../../../../../boards/sam4cp16bmb/: init.c led.h sam4cp16bmb.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../utils/cmsis/sam4cp/include/: system_sam4cp.h sam4cp_1.h sam4cp.h sam4cp16b_0.h sam4cp_0.h sam4cp16b_1.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../utils/cmsis/sam4cp/include/component/: component_cmcc.h component_rswdt.h component_pmc.h component_pwm.h component_efc.h component_rstc.h component_rtc.h component_adc.h component_trng.h component_pio.h component_uart.h component_usart.h component_smc.h component_ipc.h component_spi.h component_aes.h component_gpbr.h component_twi.h component_supc.h component_pdc.h component_chipid.h component_slcdc.h component_matrix.h component_tc.h component_icm.h component_wdt.h component_rtt.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../utils/cmsis/sam4cp/include/instance/: instance_uart0.h instance_wdt.h instance_aes.h instance_twi1.h instance_trng.h instance_adc.h instance_cmcc0.h instance_tc1.h instance_smc0.h instance_pmc.h instance_gpbr.h instance_rtt.h instance_spi0.h instance_rstc.h instance_matrix0.h instance_rswdt.h instance_pioa.h instance_tc0.h instance_matrix1.h instance_icm.h instance_piob.h instance_cmcc1.h instance_uart1.h instance_spi1.h instance_ipc0.h instance_usart3.h instance_usart1.h instance_usart4.h instance_rtc.h instance_chipid.h instance_pioc.h instance_efc.h instance_usart2.h instance_slcdc.h instance_ipc1.h instance_usart0.h instance_smc1.h instance_twi0.h instance_pwm.h instance_supc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4cp
    ../../../../../../../common/services/clock/sam4cp/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
