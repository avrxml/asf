<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ast_unit_tests_flash.ewp</path>
	</project>
</workspace>
