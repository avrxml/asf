<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ast_example2_flash.ewp</path>
	</project>
</workspace>
