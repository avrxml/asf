<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ast_example1_flash.ewp</path>
	</project>
</workspace>
