# IAR project adc_adc_threshold_wakeup_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pio; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam4c/source/templates; ../../../../../boards/sam4c_ek; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../../common/services/gpio; ..; ../../../../uart; ../../../../../utils; ../../../../tc; ../../../../../utils/cmsis/sam4c/include; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pmc; ../../../../usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_adc_threshold_wakeup_example_flash.bin
  ILINK.IlinkOutputFile: adc_adc_threshold_wakeup_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../utils/cmsis/sam4c/include/: sam4c16c_0.h sam4c.h sam4c32c_1.h sam4c32e_1.h sam4c32e_0.h system_sam4c.h sam4c8c_1.h sam4c8c_0.h sam4c16c_1.h sam4c32c_0.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../utils/cmsis/sam4c/include/instance/: instance_pioc.h instance_efc0.h instance_cmcc1.h instance_supc.h instance_pmc.h instance_chipid.h instance_rstc.h instance_piod.h instance_adc.h instance_pioa.h instance_rswdt.h instance_uotghs.h instance_uart0.h instance_smc1.h instance_cmcc0.h instance_matrix0.h instance_piob.h instance_wdt.h instance_rtt.h instance_trng.h instance_usart0.h instance_usart2.h instance_ipc1.h instance_usart4.h instance_matrix1.h instance_twi1.h instance_tc0.h instance_ipc0.h instance_spi1.h instance_usart3.h instance_aes.h instance_efc1.h instance_rtc.h instance_icm.h instance_tc1.h instance_slcdc.h instance_efc.h instance_usart1.h instance_spi0.h instance_pwm.h instance_gpbr.h instance_uart1.h instance_smc0.h instance_twi0.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../utils/cmsis/sam4c/include/component/: component_icm.h component_efc.h component_supc.h component_smc.h component_rtc.h component_matrix.h component_aes.h component_ipc.h component_pdc.h component_uotghs.h component_cmcc.h component_rtt.h component_gpbr.h component_chipid.h component_slcdc.h component_trng.h component_adc.h component_usart.h component_pio.h component_wdt.h component_rswdt.h component_twi.h component_spi.h component_tc.h component_pwm.h component_uart.h component_pmc.h component_rstc.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../utils/cmsis/sam4c/include/pio/: pio_sam4c8c.h pio_sam4c16c.h pio_sam4c32c.h pio_sam4c32e.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/adc
    ../../../: adc.c adc_sam3u.c adc.h
  group sam/drivers/adc/adc_threshold_wakeup_example
    ../../: adc_threshold_wakeup_example.c
  group sam/drivers/adc/adc_threshold_wakeup_example/sam4c16c_sam4c_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/drivers/adc/adc_threshold_wakeup_example/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/boards/sam4c_ek
    ../../../../../boards/sam4c_ek/: init.c sam4c_ek.h led.h
