# IAR project adc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/cmsis/sam4n/include; ../../../../../boards/sam4n_xplained_pro; ../../../../../utils/cmsis/sam4n/source/templates; ../../../../../utils/preprocessor; ../../../../pmc; ..; ../../../../../../common/services/serial; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/services/delay; ../../../../uart; ../../../../../utils; ../..; ../../../../tc; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: adc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4n
    ../../../../../../common/services/clock/sam4n/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/adc
    ../../../: adc2.c adc2.h
  group sam/drivers/adc/unit_tests
    ../../: unit_tests.c
  group sam/drivers/adc/unit_tests/sam4n16c_sam4n_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group sam/drivers/adc/unit_tests/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../utils/cmsis/sam4n/source/templates/: exceptions.c system_sam4n.c system_sam4n.h exceptions.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../utils/cmsis/sam4n/include/: sam4n16b.h sam4n.h sam4n16c.h sam4n8c.h sam4n8a.h sam4n8b.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../utils/cmsis/sam4n/include/instance/: instance_efc.h instance_matrix.h instance_usart2.h instance_pwm.h instance_twi2.h instance_supc.h instance_usart1.h instance_rstc.h instance_usart0.h instance_piob.h instance_adc.h instance_tc1.h instance_twi0.h instance_dacc.h instance_uart3.h instance_pioa.h instance_wdt.h instance_gpbr.h instance_uart2.h instance_pmc.h instance_pioc.h instance_twi1.h instance_tc0.h instance_rtt.h instance_uart0.h instance_uart1.h instance_spi.h instance_chipid.h instance_rtc.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../utils/cmsis/sam4n/include/pio/: pio_sam4n8b.h pio_sam4n16b.h pio_sam4n16c.h pio_sam4n8c.h pio_sam4n8a.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../utils/cmsis/sam4n/include/component/: component_rtt.h component_wdt.h component_usart.h component_chipid.h component_efc.h component_pdc.h component_spi.h component_twi.h component_pio.h component_gpbr.h component_tc.h component_adc.h component_pwm.h component_dacc.h component_pmc.h component_matrix.h component_rstc.h component_supc.h component_uart.h component_rtc.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
