# IAR project adc_adc_enhanced_resolution_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/header_files; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../efc; ..; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../../../../boards/samg53_xplained_pro; ../../../../supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/samg/samg53/include; ../../../../uart; ../../../../../utils/cmsis/samg/samg53/source/templates; ../../../../../utils; ../../../../tc; ../../../../usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_adc_enhanced_resolution_example_flash.bin
  ILINK.IlinkOutputFile: adc_adc_enhanced_resolution_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../utils/cmsis/samg/samg53/source/templates/: exceptions.c system_samg53.c system_samg53.h exceptions.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../utils/cmsis/samg/samg53/include/: samg53g19.h samg53.h samg53n19.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../utils/cmsis/samg/samg53/include/pio/: pio_samg53n19.h pio_samg53g19.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../utils/cmsis/samg/samg53/include/component/: component_rtt.h component_i2sc.h component_usart.h component_pdc.h component_pdmic.h component_rtc.h component_chipid.h component_efc.h component_uart.h component_gpbr.h component_tc.h component_rstc.h component_spi.h component_matrix.h component_twi.h component_pio.h component_mem2mem.h component_adc.h component_wdt.h component_pmc.h component_supc.h component_twihs.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../utils/cmsis/samg/samg53/include/instance/: instance_tc0.h instance_pdmic0.h instance_pdmic1.h instance_mem2mem.h instance_adc.h instance_usart.h instance_chipid.h instance_piob.h instance_i2sc1.h instance_uart0.h instance_twi2.h instance_rstc.h instance_pioa.h instance_efc.h instance_i2sc0.h instance_spi.h instance_twi0.h instance_uart1.h instance_rtc.h instance_tc1.h instance_twi1.h instance_supc.h instance_wdt.h instance_pmc.h instance_matrix.h instance_gpbr.h instance_rtt.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/drivers/efc
    ../../../../efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/supc
    ../../../../supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/drivers/adc
    ../../../: adc2.c adc2.h
  group sam/drivers/adc/adc_enhanced_resolution_example
    ../../: adc_enhanced_resolution_example.c
  group sam/drivers/adc/adc_enhanced_resolution_example/samg53n19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h
  group sam/drivers/adc/adc_enhanced_resolution_example/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group sam/boards/samg53_xplained_pro
    ../../../../../boards/samg53_xplained_pro/: board_init.c led.h samg53_xplained_pro.h
