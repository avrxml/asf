<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_adc_enhanced_resolution_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\adc_adc_enhanced_resolution_example_sram.ewp</path>
	</project>
</workspace>
