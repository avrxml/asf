<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_adc_enhanced_mode_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\adc_adc_enhanced_mode_sram.ewp</path>
	</project>
</workspace>
