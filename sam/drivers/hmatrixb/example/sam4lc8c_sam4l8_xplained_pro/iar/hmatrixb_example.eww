<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hmatrixb_example_flash.ewp</path>
	</project>
</workspace>
