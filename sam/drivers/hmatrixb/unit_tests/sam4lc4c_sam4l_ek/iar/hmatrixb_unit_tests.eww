<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hmatrixb_unit_tests_flash.ewp</path>
	</project>
</workspace>
