<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_spi_pdc_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\spi_spi_pdc_example_sram.ewp</path>
	</project>
</workspace>
