# IAR project spi_spi_pdc_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../utils/cmsis/sam4s/include; ..; ../../../../../../common/services/serial; ../../..; ../../../../supc; ../../../../pdc; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../../common/services/delay; ../../../../uart; ../../../../../boards/atpl230amb; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_spi_pdc_example_flash.bin
  ILINK.IlinkOutputFile: spi_spi_pdc_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/spi
    ../../../: spi.c spi.h
  group sam/drivers/spi/spi_pdc_example
    ../../: spi_pdc_example.c
  group sam/drivers/spi/spi_pdc_example/sam4sd32c_atpl230amb
    ../: conf_uart_serial.h conf_board.h conf_spi_pdc_example.h conf_clock.h
  group sam/drivers/spi/spi_pdc_example/sam4sd32c_atpl230amb/iar
    ./: asf.h
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/drivers/supc
    ../../../../supc/: supc.c supc.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../utils/cmsis/sam4s/include/: sam4sd32b.h sam4s16c.h sam4s4b.h sam4s4a.h sam4sa16c.h sam4s.h sam4sd32c.h sam4s8c.h sam4s2a.h sam4s2c.h sam4sd16b.h sam4sa16b.h sam4s8b.h sam4s2b.h sam4s16b.h system_sam4s.h sam4sd16c.h sam4s4c.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../utils/cmsis/sam4s/include/pio/: pio_sam4sd16c.h pio_sam4s8b.h pio_sam4s2b.h pio_sam4sd32b.h pio_sam4s8c.h pio_sam4sa16b.h pio_sam4sd32c.h pio_sam4s2c.h pio_sam4s4a.h pio_sam4sa16c.h pio_sam4s2a.h pio_sam4s4c.h pio_sam4s16b.h pio_sam4sd16b.h pio_sam4s4b.h pio_sam4s16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../utils/cmsis/sam4s/include/instance/: instance_usart0.h instance_hsmci.h instance_rstc.h instance_crccu.h instance_dacc.h instance_efc0.h instance_gpbr.h instance_udp.h instance_tc0.h instance_spi.h instance_acc.h instance_chipid.h instance_rtt.h instance_pioa.h instance_pioc.h instance_pwm.h instance_ssc.h instance_tc1.h instance_twi0.h instance_usart1.h instance_pmc.h instance_rtc.h instance_supc.h instance_uart1.h instance_piob.h instance_matrix.h instance_smc.h instance_uart0.h instance_wdt.h instance_cmcc.h instance_adc.h instance_efc1.h instance_twi1.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../utils/cmsis/sam4s/include/component/: component_spi.h component_pwm.h component_gpbr.h component_pdc.h component_rtt.h component_supc.h component_dacc.h component_efc.h component_pio.h component_rstc.h component_chipid.h component_smc.h component_matrix.h component_cmcc.h component_uart.h component_wdt.h component_twi.h component_hsmci.h component_pmc.h component_adc.h component_udp.h component_usart.h component_rtc.h component_crccu.h component_acc.h component_ssc.h component_tc.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/atpl230amb
    ../../../../../boards/atpl230amb/: init.c led.h atpl230amb.h
