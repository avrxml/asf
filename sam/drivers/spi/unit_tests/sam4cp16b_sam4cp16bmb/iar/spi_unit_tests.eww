<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_unit_tests_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\spi_unit_tests_sram.ewp</path>
	</project>
</workspace>
