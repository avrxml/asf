<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aesa_example_flash.ewp</path>
	</project>
</workspace>
