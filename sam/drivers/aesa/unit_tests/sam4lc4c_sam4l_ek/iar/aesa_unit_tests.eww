<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aesa_unit_tests_flash.ewp</path>
	</project>
</workspace>
