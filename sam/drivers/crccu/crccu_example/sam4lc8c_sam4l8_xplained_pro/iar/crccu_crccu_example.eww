<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\crccu_crccu_example_flash.ewp</path>
	</project>
</workspace>
