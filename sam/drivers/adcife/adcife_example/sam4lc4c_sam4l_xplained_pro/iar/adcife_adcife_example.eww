<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adcife_adcife_example_flash.ewp</path>
	</project>
</workspace>
