# IAR project adcife_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4LC8C__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../pdca; ../../../../../utils/cmsis/sam4l/include; ../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../common/services/serial; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../wdt; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../..; ..; ../../../../../../common/services/delay; ../../../../../utils; ../../../../dacc; ../../../../usart; ../../../../../utils/header_files; ../../../../flashcalw; ../../../../../../common/services/ioport; ../../../../../boards/sam4l8_xplained_pro; ../../../../bpm; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adcife_unit_tests_flash.bin
  ILINK.IlinkOutputFile: adcife_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h dfll.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: pll.c osc.c sysclk.c dfll.c pll.h dfll.h genclk.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/adcife
    ../../../: adcife.c adcife.h
  group sam/drivers/adcife/unit_tests
    ../../: unit_tests.c
  group sam/drivers/adcife/unit_tests/sam4lc8c_sam4l8_xplained_pro
    ../: conf_adcife.h conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group sam/drivers/adcife/unit_tests/sam4lc8c_sam4l8_xplained_pro/iar
    ./: asf.h
  group sam/drivers/flashcalw
    ../../../../flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/wdt
    ../../../../wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../bpm/: bpm.c bpm.h
  group sam/drivers/pdca
    ../../../../pdca/: pdca.c pdca.h
  group sam/drivers/dacc
    ../../../../dacc/: dacc.c dacc.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../boards/sam4l8_xplained_pro/: init.c sam4l8_xplained_pro.h led.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../utils/cmsis/sam4l/include/: sam4lc4c.h sam4lc8c.h sam4lc2b.h sam4lc2a.h sam4ls4b.h sam4ls2b.h sam4ls8b.h sam4ls4c.h sam4ls2a.h sam4ls2c.h sam4lc2c.h sam4ls4a.h sam4ls8c.h sam4ls8a.h sam4l.h sam4lc4b.h sam4lc8a.h sam4lc4a.h sam4lc8b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../utils/cmsis/sam4l/include/instance/: instance_eic.h instance_crccu.h instance_twim2.h instance_trng.h instance_wdt.h instance_dacc.h instance_usart0.h instance_twis0.h instance_usart1.h instance_gloc.h instance_chipid.h instance_tc1.h instance_catb.h instance_bscif.h instance_scif.h instance_usart3.h instance_abdacb.h instance_usbc.h instance_freqm.h instance_gpio.h instance_hcache.h instance_tc0.h instance_pevc.h instance_pm.h instance_twim3.h instance_smap.h instance_twim1.h instance_hmatrix.h instance_twis1.h instance_parc.h instance_iisc.h instance_bpm.h instance_usart2.h instance_adcife.h instance_picouart.h instance_aesa.h instance_spi.h instance_ast.h instance_twim0.h instance_pdca.h instance_hflashc.h instance_acifc.h instance_lcdca.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../utils/cmsis/sam4l/include/component/: component_crccu.h component_dacc.h component_twim.h component_bpm.h component_wdt.h component_lcdca.h component_chipid.h component_aesa.h component_flashcalw.h component_trng.h component_pevc.h component_usart.h component_spi.h component_parc.h component_freqm.h component_pm.h component_acifc.h component_gloc.h component_smap.h component_twis.h component_ast.h component_pdca.h component_picouart.h component_tc.h component_scif.h component_hcache.h component_catb.h component_iisc.h component_bscif.h component_gpio.h component_usbc.h component_eic.h component_adcife.h component_hmatrixb.h component_abdacb.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../utils/cmsis/sam4l/include/pio/: pio_sam4ls4b.h pio_sam4ls8a.h pio_sam4ls8c.h pio_sam4lc8b.h pio_sam4ls2b.h pio_sam4lc2c.h pio_sam4ls4c.h pio_sam4lc8a.h pio_sam4lc8c.h pio_sam4ls8b.h pio_sam4lc2b.h pio_sam4lc4b.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls2a.h pio_sam4lc2a.h pio_sam4lc4a.h pio_sam4lc4c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
