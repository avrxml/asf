<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adcife_unit_tests_flash.ewp</path>
	</project>
</workspace>
