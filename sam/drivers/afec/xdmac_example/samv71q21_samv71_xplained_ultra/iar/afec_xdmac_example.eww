<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\afec_xdmac_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\afec_xdmac_example_sram.ewp</path>
	</project>
</workspace>
