# IAR project afec_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAME70_XPLAINED; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/same70/source/templates; ../../../../pmc; ../../../../../utils/cmsis/same70/include; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../../../mpu; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/same70_xplained; ../../../../../../common/services/gpio; ../../../../../../common/services/delay; ../../../../uart; ../../../../../utils; ../../../../tc; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ../../..; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: afec_unit_tests_flash.bin
  ILINK.IlinkOutputFile: afec_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../utils/cmsis/same70/include/: same70q21b.h same70n19b.h same70n19.h same70q20.h same70q20b.h same70q19.h same70n20b.h same70n21b.h same70j21b.h same70.h same70j21.h same70n21.h same70j20.h same70j19.h same70q21.h same70j19b.h same70q19b.h same70n20.h same70j20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../utils/cmsis/same70/include/component/: gpbr.h rstc.h gmac.h aes.h chipid.h xdmac.h uart.h hsmci.h isi.h pio.h spi.h usart.h supc.h tc.h i2sc.h usbhs.h qspi.h icm.h sdramc.h pmc.h rtt.h efc.h rswdt.h twihs.h acc.h dacc.h smc.h pwm.h matrix.h wdt.h utmi.h ssc.h rtc.h afec.h mcan.h trng.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../utils/cmsis/same70/include/instance/: spi1.h twihs0.h twihs2.h smc.h matrix.h sdramc.h usart0.h afec0.h uart3.h pwm1.h uart2.h mcan1.h usbhs.h pioe.h tc1.h uart0.h chipid.h tc3.h rtt.h rswdt.h icm.h dacc.h pmc.h usart2.h hsmci.h mcan0.h wdt.h utmi.h gmac.h tc2.h supc.h rstc.h aes.h efc.h uart1.h i2sc1.h pioa.h ssc.h piob.h tc0.h i2sc0.h twihs1.h acc.h afec1.h spi0.h usart1.h isi.h qspi.h trng.h pwm0.h uart4.h xdmac.h gpbr.h pioc.h rtc.h piod.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../utils/cmsis/same70/include/pio/: same70j20b.h same70n20.h same70q20b.h same70q21b.h same70j21b.h same70j21.h same70q19b.h same70n21.h same70n21b.h same70n19.h same70q20.h same70q19.h same70n20b.h same70j19b.h same70j20.h same70q21.h same70j19.h same70n19b.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/afec
    ../../../: afec.c afec.h
  group sam/drivers/afec/unit_tests
    ../../: unit_tests.c
  group sam/drivers/afec/unit_tests/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group sam/drivers/afec/unit_tests/same70q21_same70_xplained/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/mpu
    ../../../../mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/boards/same70_xplained
    ../../../../../boards/same70_xplained/: init.c same70_xplained.h led.h
