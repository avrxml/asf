# IAR project afec_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../boards/samv71_xplained_ultra; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../../../mpu; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../..; ../../../../../utils/cmsis/samv71/source/templates; ..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/delay; ../../../../uart; ../../../../../utils; ../../../../tc; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ../../..; ../../../../../utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: afec_unit_tests_flash.bin
  ILINK.IlinkOutputFile: afec_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samv71
    ../../../../../../common/services/clock/samv71/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/mpu
    ../../../../mpu/: mpu.c mpu.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/drivers/afec
    ../../../: afec.c afec.h
  group sam/drivers/afec/unit_tests
    ../../: unit_tests.c
  group sam/drivers/afec/unit_tests/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group sam/drivers/afec/unit_tests/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../utils/cmsis/samv71/include/: samv71n19b.h samv71n19.h samv71n20.h samv71n21b.h samv71j19.h samv71j20b.h samv71n20b.h samv71q19b.h samv71j21b.h samv71q21.h samv71.h samv71q20b.h samv71j21.h samv71q20.h samv71j19b.h samv71q21b.h samv71n21.h samv71j20.h samv71q19.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../utils/cmsis/samv71/include/instance/: tc0.h piod.h sdramc.h i2sc1.h rtt.h aes.h trng.h uart0.h rstc.h acc.h uart1.h tc2.h icm.h piob.h spi1.h usart0.h efc.h chipid.h dacc.h hsmci.h usbhs.h mcan0.h afec0.h gpbr.h pioa.h utmi.h uart4.h rswdt.h rtc.h pioe.h gmac.h afec1.h smc.h twihs2.h mcan1.h mlb.h twihs1.h ssc.h pwm1.h tc3.h matrix.h tc1.h uart3.h pwm0.h qspi.h xdmac.h twihs0.h isi.h wdt.h usart2.h pioc.h uart2.h i2sc0.h pmc.h supc.h spi0.h usart1.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../utils/cmsis/samv71/include/component/: xdmac.h usart.h gmac.h pio.h smc.h rstc.h isi.h trng.h rtt.h pwm.h icm.h rswdt.h mcan.h supc.h aes.h i2sc.h efc.h utmi.h mlb.h usbhs.h twihs.h hsmci.h spi.h afec.h acc.h tc.h pmc.h wdt.h qspi.h uart.h ssc.h matrix.h rtc.h chipid.h dacc.h sdramc.h gpbr.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../utils/cmsis/samv71/include/pio/: samv71j21b.h samv71q20b.h samv71q20.h samv71j20b.h samv71n19b.h samv71q19b.h samv71j19b.h samv71q21b.h samv71n20.h samv71j19.h samv71n19.h samv71j20.h samv71n21.h samv71n21b.h samv71n20b.h samv71j21.h samv71q21.h samv71q19.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
