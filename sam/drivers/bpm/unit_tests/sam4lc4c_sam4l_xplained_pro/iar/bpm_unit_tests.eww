<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bpm_unit_tests_flash.ewp</path>
	</project>
</workspace>
