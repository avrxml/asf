<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pdc_pdc_uart_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\pdc_pdc_uart_example_sram.ewp</path>
	</project>
</workspace>
