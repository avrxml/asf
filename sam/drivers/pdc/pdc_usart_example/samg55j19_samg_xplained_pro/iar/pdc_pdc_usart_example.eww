<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pdc_pdc_usart_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\pdc_pdc_usart_example_sram.ewp</path>
	</project>
</workspace>
