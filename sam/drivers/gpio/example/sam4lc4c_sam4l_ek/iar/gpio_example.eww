<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gpio_example_flash.ewp</path>
	</project>
</workspace>
