<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gpio_unit_tests_flash.ewp</path>
	</project>
</workspace>
