<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\events_example2_flash.ewp</path>
	</project>
</workspace>
