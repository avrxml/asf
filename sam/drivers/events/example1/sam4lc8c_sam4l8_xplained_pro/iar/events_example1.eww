<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\events_example1_flash.ewp</path>
	</project>
</workspace>
