<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\events_unit_tests_flash.ewp</path>
	</project>
</workspace>
