<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pio_alternate_function_example_flash.ewp</path>
	</project>
</workspace>
