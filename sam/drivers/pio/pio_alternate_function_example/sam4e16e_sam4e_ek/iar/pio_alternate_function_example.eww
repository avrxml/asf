<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pio_alternate_function_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\pio_alternate_function_example_sram.ewp</path>
	</project>
</workspace>
