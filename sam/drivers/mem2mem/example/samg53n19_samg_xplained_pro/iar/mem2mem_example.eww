<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mem2mem_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mem2mem_example_sram.ewp</path>
	</project>
</workspace>
