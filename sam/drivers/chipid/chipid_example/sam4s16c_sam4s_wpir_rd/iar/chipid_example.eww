<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\chipid_example_flash.ewp</path>
	</project>
</workspace>
