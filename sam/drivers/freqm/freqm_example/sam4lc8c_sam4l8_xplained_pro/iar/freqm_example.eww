<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freqm_example_flash.ewp</path>
	</project>
</workspace>
