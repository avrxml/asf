<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freqm_unit_tests_flash.ewp</path>
	</project>
</workspace>
