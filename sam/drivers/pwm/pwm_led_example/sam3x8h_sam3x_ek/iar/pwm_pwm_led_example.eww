<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pwm_pwm_led_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\pwm_pwm_led_example_sram.ewp</path>
	</project>
</workspace>
