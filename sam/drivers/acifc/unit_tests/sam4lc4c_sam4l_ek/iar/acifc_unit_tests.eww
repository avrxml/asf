<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\acifc_unit_tests_flash.ewp</path>
	</project>
</workspace>
