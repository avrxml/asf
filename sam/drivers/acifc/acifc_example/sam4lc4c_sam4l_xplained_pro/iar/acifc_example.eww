<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\acifc_example_flash.ewp</path>
	</project>
</workspace>
