<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\uart_uart_sleepwalking_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\uart_uart_sleepwalking_example_sram.ewp</path>
	</project>
</workspace>
