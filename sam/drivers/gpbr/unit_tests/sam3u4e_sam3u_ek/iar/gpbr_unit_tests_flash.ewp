# IAR project gpbr_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/cmsis/sam3u/source/templates; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../efc; ../../../../../../common/services/serial; ../../..; ../../../../../services/flash_efc; ../../../../supc; ../../../../../../common/utils; ..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3u_ek; ../../../../../utils/cmsis/sam3u/include; ../../../../../../common/services/gpio; ../../../../uart; ../../../../rtt; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gpbr_unit_tests_flash.bin
  ILINK.IlinkOutputFile: gpbr_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: led.c init.c led.h sam3u_ek.h
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/gpbr
    ../../../: gpbr.c gpbr.h
  group sam/drivers/gpbr/unit_tests
    ../../: unit_tests.c
  group sam/drivers/gpbr/unit_tests/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_board.h conf_test.h conf_clock.h
  group sam/drivers/gpbr/unit_tests/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group sam/drivers/rtt
    ../../../../rtt/: rtt.c rtt.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/efc
    ../../../../efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/supc
    ../../../../supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c exceptions.h system_sam3u.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../utils/cmsis/sam3u/include/: sam3u4e.h sam3u2c.h sam3u4c.h sam3u1e.h sam3u2e.h sam3u.h sam3u1c.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../utils/cmsis/sam3u/include/pio/: pio_sam3u4c.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u2e.h pio_sam3u2c.h pio_sam3u4e.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../utils/cmsis/sam3u/include/component/: component_supc.h component_gpbr.h component_spi.h component_pdc.h component_hsmci.h component_pio.h component_adc12b.h component_dmac.h component_wdt.h component_rtc.h component_usart.h component_rstc.h component_udphs.h component_tc.h component_pmc.h component_chipid.h component_efc.h component_pwm.h component_matrix.h component_twi.h component_uart.h component_ssc.h component_adc.h component_smc.h component_rtt.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../utils/cmsis/sam3u/include/instance/: instance_spi.h instance_usart1.h instance_usart3.h instance_matrix.h instance_ssc.h instance_piob.h instance_pioa.h instance_smc.h instance_usart0.h instance_usart2.h instance_rtc.h instance_twi1.h instance_pioc.h instance_efc0.h instance_supc.h instance_rstc.h instance_gpbr.h instance_adc.h instance_adc12b.h instance_hsmci.h instance_chipid.h instance_efc1.h instance_twi0.h instance_tc0.h instance_udphs.h instance_pwm.h instance_uart.h instance_dmac.h instance_rtt.h instance_pmc.h instance_wdt.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c sysclk.h pll.h osc.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
