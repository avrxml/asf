<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pmc_pmc_clock_switching_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\pmc_pmc_clock_switching_example_sram.ewp</path>
	</project>
</workspace>
