<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pmc_pmc_clock_failure_detect_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\pmc_pmc_clock_failure_detect_example_sram.ewp</path>
	</project>
</workspace>
