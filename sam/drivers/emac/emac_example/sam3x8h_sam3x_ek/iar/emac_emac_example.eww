<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\emac_emac_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\emac_emac_example_sram.ewp</path>
	</project>
</workspace>
