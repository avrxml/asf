# IAR project emac_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../rstc; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../boards/sam3x_ek; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../efc; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/include; ../../../../../services/flash_efc; ../../../../../../common/utils; ../../..; ..; ../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../components/ethernet_phy/dm9161a; ../../../../../../common/services/ioport; ../../../../pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: emac_unit_tests_flash.bin
  ILINK.IlinkOutputFile: emac_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/components/ethernet_phy
    ../../../../../components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/dm9161a
    ../../../../../components/ethernet_phy/dm9161a/: ethernet_phy.c ethernet_phy.h mii.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../utils/cmsis/sam3x/include/: sam3xa.h sam3a4c.h sam3x4c.h sam3x8c.h sam3a8c.h sam3x8e.h sam3x8h.h sam3x4e.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../utils/cmsis/sam3x/include/instance/: instance_hsmci.h instance_usart0.h instance_can0.h instance_matrix.h instance_pioe.h instance_piof.h instance_smc.h instance_piob.h instance_chipid.h instance_ssc.h instance_efc1.h instance_adc.h instance_piod.h instance_spi1.h instance_usart3.h instance_rstc.h instance_tc0.h instance_usart2.h instance_uart.h instance_tc2.h instance_wdt.h instance_trng.h instance_twi1.h instance_efc0.h instance_rtc.h instance_pwm.h instance_dmac.h instance_dacc.h instance_can1.h instance_supc.h instance_rtt.h instance_emac.h instance_usart1.h instance_tc1.h instance_gpbr.h instance_twi0.h instance_uotghs.h instance_spi0.h instance_pioc.h instance_pmc.h instance_sdramc.h instance_pioa.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3x8h.h pio_sam3x8e.h pio_sam3x8c.h pio_sam3x4c.h pio_sam3x4e.h pio_sam3a4c.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../utils/cmsis/sam3x/include/component/: component_twi.h component_smc.h component_uart.h component_spi.h component_efc.h component_adc.h component_supc.h component_pdc.h component_trng.h component_can.h component_tc.h component_wdt.h component_ssc.h component_rstc.h component_chipid.h component_pwm.h component_usart.h component_matrix.h component_dmac.h component_pmc.h component_hsmci.h component_uotghs.h component_gpbr.h component_pio.h component_rtt.h component_sdramc.h component_emac.h component_rtc.h component_dacc.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/emac
    ../../../: emac.c emac.h
  group sam/drivers/emac/unit_tests
    ../../: unit_tests.c mini_ip.h
  group sam/drivers/emac/unit_tests/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_eth.h conf_test.h
  group sam/drivers/emac/unit_tests/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/efc
    ../../../../efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../rstc/: rstc.c rstc.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c led.c led.h sam3x_ek.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
