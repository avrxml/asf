<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\smc_smc_sram_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\smc_smc_sram_example_sram.ewp</path>
	</project>
</workspace>
