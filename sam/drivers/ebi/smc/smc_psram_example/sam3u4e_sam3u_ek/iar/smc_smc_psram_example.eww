<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\smc_smc_psram_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\smc_smc_psram_example_sram.ewp</path>
	</project>
</workspace>
