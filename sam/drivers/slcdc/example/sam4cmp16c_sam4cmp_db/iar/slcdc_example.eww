<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\slcdc_example_flash.ewp</path>
	</project>
</workspace>
