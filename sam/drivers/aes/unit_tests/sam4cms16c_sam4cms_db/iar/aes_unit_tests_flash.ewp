# IAR project aes_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../..; ../../../../../utils/preprocessor; ..; ../../../../pmc; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam4cm/source/templates; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../pdc; ../../../../../boards/sam4cms_db; ../../..; ../../../../../../common/services/delay; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils/cmsis/sam4cm/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: aes_unit_tests_flash.bin
  ILINK.IlinkOutputFile: aes_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4cm/iar/sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/aes
    ../../../: aes.c aes.h
  group sam/drivers/aes/unit_tests
    ../../: unit_tests.c
  group sam/drivers/aes/unit_tests/sam4cms16c_sam4cms_db
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h conf_sleepmgr.h
  group sam/drivers/aes/unit_tests/sam4cms16c_sam4cms_db/iar
    ./: asf.h
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../utils/cmsis/sam4cm/include/: sam4cms16c_1.h sam4cms8c_1.h sam4cmp16c_0.h sam4cms16c_0.h sam4cm.h sam4cmp16c_1.h sam4cms8c_0.h sam4cmp8c_0.h system_sam4cm.h sam4cmp8c_1.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../utils/cmsis/sam4cm/include/component/: gpbr.h aes.h pdc.h pio.h smc.h icm.h rtc.h matrix.h pwm.h slcdc.h cmcc.h spi.h uart.h tc.h pmc.h twi.h rtt.h rswdt.h efc.h trng.h wdt.h adc.h ipc.h chipid.h usart.h supc.h rstc.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../utils/cmsis/sam4cm/include/instance/: efc.h rswdt.h pioa.h usart0.h usart2.h twi1.h rstc.h trng.h cmcc0.h slcdc.h rtc.h ipc0.h twi0.h pmc.h spi1.h cmcc1.h matrix1.h tc1.h gpbr.h icm.h adc.h uart1.h piob.h ipc1.h rtt.h wdt.h aes.h uart0.h matrix0.h pwm.h chipid.h usart1.h smc0.h usart3.h smc1.h tc0.h spi0.h pioc.h supc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cms16c.h sam4cmp8c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4cms_db
    ../../../../../boards/sam4cms_db/: init.c led.h sam4cms_db.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
