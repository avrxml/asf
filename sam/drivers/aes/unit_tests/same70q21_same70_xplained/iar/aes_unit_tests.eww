<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_unit_tests_flash.ewp</path>
	</project>
</workspace>
