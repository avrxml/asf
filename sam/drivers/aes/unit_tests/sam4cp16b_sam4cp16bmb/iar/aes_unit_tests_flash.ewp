# IAR project aes_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4CP16BMB; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../..; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../utils/cmsis/sam4cp/source/templates; ../../../../../utils/cmsis/sam4cp/include; ../../../../../../common/services/serial; ..; ../../../../supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../boards/sam4cp16bmb; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../pdc; ../../..; ../../../../../../common/services/delay; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: aes_unit_tests_flash.bin
  ILINK.IlinkOutputFile: aes_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/aes
    ../../../: aes.c aes.h
  group sam/drivers/aes/unit_tests
    ../../: unit_tests.c
  group sam/drivers/aes/unit_tests/sam4cp16b_sam4cp16bmb
    ../: conf_uart_serial.h conf_board.h conf_sleepmgr.h conf_test.h conf_clock.h
  group sam/drivers/aes/unit_tests/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/supc
    ../../../../supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../utils/cmsis/sam4cp/include/: system_sam4cp.h sam4cp_0.h sam4cp.h sam4cp_1.h sam4cp16b_1.h sam4cp16b_0.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../utils/cmsis/sam4cp/include/instance/: instance_supc.h instance_piob.h instance_icm.h instance_pioa.h instance_pwm.h instance_adc.h instance_spi1.h instance_uart0.h instance_twi0.h instance_rtt.h instance_matrix0.h instance_aes.h instance_gpbr.h instance_rtc.h instance_rswdt.h instance_ipc1.h instance_smc0.h instance_rstc.h instance_usart2.h instance_usart0.h instance_wdt.h instance_trng.h instance_cmcc1.h instance_usart4.h instance_ipc0.h instance_matrix1.h instance_smc1.h instance_chipid.h instance_pmc.h instance_spi0.h instance_pioc.h instance_usart3.h instance_usart1.h instance_efc.h instance_slcdc.h instance_cmcc0.h instance_tc1.h instance_uart1.h instance_twi1.h instance_tc0.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../utils/cmsis/sam4cp/include/component/: component_pmc.h component_cmcc.h component_twi.h component_uart.h component_adc.h component_rtt.h component_icm.h component_wdt.h component_smc.h component_slcdc.h component_matrix.h component_pdc.h component_gpbr.h component_pio.h component_rswdt.h component_pwm.h component_rtc.h component_aes.h component_spi.h component_ipc.h component_efc.h component_trng.h component_usart.h component_supc.h component_tc.h component_chipid.h component_rstc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4cp16bmb
    ../../../../../boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h sysclk.h pll.h osc.h
  group common/services/clock/sam4cp
    ../../../../../../common/services/clock/sam4cp/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
