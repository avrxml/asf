<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gcm_example_flash.ewp</path>
	</project>
</workspace>
