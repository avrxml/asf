<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_example_flash.ewp</path>
	</project>
</workspace>
