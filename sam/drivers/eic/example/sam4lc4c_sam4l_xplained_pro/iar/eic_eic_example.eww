<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eic_eic_example_flash.ewp</path>
	</project>
</workspace>
