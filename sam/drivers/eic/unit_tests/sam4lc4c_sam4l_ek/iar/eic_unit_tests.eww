<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eic_unit_tests_flash.ewp</path>
	</project>
</workspace>
