<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twis_twi_slave_example_flash.ewp</path>
	</project>
</workspace>
