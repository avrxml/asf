<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dacc_sinewave_example_flash.ewp</path>
	</project>
</workspace>
