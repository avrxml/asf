<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dacc_sinewave_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\dacc_sinewave_example_sram.ewp</path>
	</project>
</workspace>
