<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twihs_twihs_master_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\twihs_twihs_master_example_sram.ewp</path>
	</project>
</workspace>
