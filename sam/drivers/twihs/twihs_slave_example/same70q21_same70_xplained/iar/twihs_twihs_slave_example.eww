<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twihs_twihs_slave_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\twihs_twihs_slave_example_sram.ewp</path>
	</project>
</workspace>
