<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_usart_sleepwalking_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\usart_usart_sleepwalking_example_sram.ewp</path>
	</project>
</workspace>
