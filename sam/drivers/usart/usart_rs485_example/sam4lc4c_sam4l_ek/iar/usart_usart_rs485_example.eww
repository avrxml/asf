<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_usart_rs485_example_flash.ewp</path>
	</project>
</workspace>
