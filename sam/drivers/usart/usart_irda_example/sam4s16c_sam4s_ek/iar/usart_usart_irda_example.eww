<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_usart_irda_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\usart_usart_irda_example_sram.ewp</path>
	</project>
</workspace>
