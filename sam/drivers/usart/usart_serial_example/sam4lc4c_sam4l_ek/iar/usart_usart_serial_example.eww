<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_usart_serial_example_flash.ewp</path>
	</project>
</workspace>
