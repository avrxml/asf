# IAR project usart_usart_hard_handshaking_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/cmsis/sam3u/source/templates; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../../common/services/serial; ../../../../pdc; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3u_ek; ../../../../../utils/cmsis/sam3u/include; ../..; ../../../../../../common/services/gpio; ../../../../pdc/pdc_uart_example; ../../../../uart; ../../../../../utils; ../../../../tc; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_hard_handshaking_example_sram.bin
  ILINK.IlinkOutputFile: usart_usart_hard_handshaking_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: led.c init.c led.h sam3u_ek.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c exceptions.h system_sam3u.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../utils/cmsis/sam3u/include/: sam3u4e.h sam3u2c.h sam3u4c.h sam3u1e.h sam3u2e.h sam3u.h sam3u1c.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../utils/cmsis/sam3u/include/pio/: pio_sam3u4c.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u2e.h pio_sam3u2c.h pio_sam3u4e.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../utils/cmsis/sam3u/include/component/: component_supc.h component_gpbr.h component_spi.h component_pdc.h component_hsmci.h component_pio.h component_adc12b.h component_dmac.h component_wdt.h component_usart.h component_rstc.h component_udphs.h component_tc.h component_pmc.h component_efc.h component_pwm.h component_matrix.h component_twi.h component_uart.h component_ssc.h component_chipid.h component_adc.h component_smc.h component_rtt.h component_rtc.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../utils/cmsis/sam3u/include/instance/: instance_spi.h instance_usart1.h instance_usart3.h instance_matrix.h instance_ssc.h instance_piob.h instance_hsmci.h instance_pioa.h instance_smc.h instance_chipid.h instance_usart2.h instance_rtc.h instance_pioc.h instance_efc0.h instance_supc.h instance_rstc.h instance_gpbr.h instance_adc.h instance_adc12b.h instance_usart0.h instance_efc1.h instance_twi0.h instance_twi1.h instance_tc0.h instance_udphs.h instance_pwm.h instance_uart.h instance_dmac.h instance_rtt.h instance_pmc.h instance_wdt.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../: usart.c usart.h
  group sam/drivers/usart/usart_hard_handshaking_example
    ../../: usart_hard_handshaking_example.c
  group sam/drivers/usart/usart_hard_handshaking_example/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_example.h
  group sam/drivers/usart/usart_hard_handshaking_example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c sysclk.h pll.h osc.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
