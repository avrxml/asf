# IAR project usart_usart_hard_handshaking_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam3s/include; ../../../../../utils/preprocessor; ../../../../pmc; ..; ../../../../../../common/services/serial; ../../../../pdc; ../../../../../../common/utils; ../../../../../utils/cmsis/sam3s/source/templates; ../../../../../boards/sam3s_ek; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../../common/services/gpio; ../../../../../../common/services/serial/sam_uart; ../../../../pdc/pdc_uart_example; ../../../../uart; ../../../../../utils; ../../../../tc; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_hard_handshaking_example_flash.bin
  ILINK.IlinkOutputFile: usart_usart_hard_handshaking_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c system_sam3s.h exceptions.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../../../utils/cmsis/sam3s/include/: sam3s1a.h sam3s2b.h sam3s.h sam3s4a.h sam3s1b.h sam3s2a.h sam3s4b.h sam3s1c.h sam3s4c.h sam3s2c.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../../../utils/cmsis/sam3s/include/component/: component_supc.h component_usart.h component_rstc.h component_adc.h component_ssc.h component_pmc.h component_spi.h component_dacc.h component_wdt.h component_efc.h component_smc.h component_twi.h component_matrix.h component_pio.h component_tc.h component_hsmci.h component_gpbr.h component_chipid.h component_acc.h component_udp.h component_pdc.h component_rtc.h component_pwm.h component_uart.h component_rtt.h component_crccu.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../../../utils/cmsis/sam3s/include/instance/: instance_pwm.h instance_crccu.h instance_rtt.h instance_piob.h instance_rstc.h instance_chipid.h instance_efc.h instance_acc.h instance_rtc.h instance_uart0.h instance_tc1.h instance_adc.h instance_pioc.h instance_pioa.h instance_wdt.h instance_hsmci.h instance_twi0.h instance_spi.h instance_matrix.h instance_uart1.h instance_tc0.h instance_usart1.h instance_pmc.h instance_gpbr.h instance_dacc.h instance_supc.h instance_udp.h instance_ssc.h instance_twi1.h instance_usart0.h instance_smc.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../../../utils/cmsis/sam3s/include/pio/: pio_sam3s4a.h pio_sam3s1a.h pio_sam3s2c.h pio_sam3s2a.h pio_sam3s4c.h pio_sam3s2b.h pio_sam3s4b.h pio_sam3s1c.h pio_sam3s1b.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../: usart.c usart.h
  group sam/drivers/usart/usart_hard_handshaking_example
    ../../: usart_hard_handshaking_example.c
  group sam/drivers/usart/usart_hard_handshaking_example/sam3s4c_sam3s_ek
    ../: conf_example.h conf_uart_serial.h conf_clock.h conf_board.h
  group sam/drivers/usart/usart_hard_handshaking_example/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: led.c init.c led.h sam3s_ek.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
