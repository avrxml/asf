<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\picouart_example1_flash.ewp</path>
	</project>
</workspace>
