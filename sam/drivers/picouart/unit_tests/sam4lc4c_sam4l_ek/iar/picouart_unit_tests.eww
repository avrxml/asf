<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\picouart_unit_tests_flash.ewp</path>
	</project>
</workspace>
