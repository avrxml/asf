# IAR project gmac_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4E_XPLAINED_PRO; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../../components/ethernet_phy/ksz8051mnl; ../../../../../boards/sam4e_xplained_pro; ../../../../pmc; ../../../../efc; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../../../../services/flash_efc; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../../../common/utils; ../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/sam4e/include; ../..; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gmac_unit_tests_flash.bin
  ILINK.IlinkOutputFile: gmac_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../utils/cmsis/sam4e/include/: sam4e.h sam4e16c.h sam4e8e.h sam4e8c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../utils/cmsis/sam4e/include/component/: cmcc.h supc.h matrix.h usart.h wdt.h gpbr.h rtc.h efc.h dacc.h rtt.h acc.h smc.h udp.h aes.h dmac.h hsmci.h chipid.h afec.h pmc.h spi.h rstc.h can.h rswdt.h gmac.h tc.h uart.h pdc.h crccu.h pio.h twi.h pwm.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../utils/cmsis/sam4e/include/instance/: wdt.h spi.h tc1.h cmcc.h chipid.h rswdt.h twi0.h pmc.h crccu.h pioc.h udp.h pwm.h efc.h acc.h rtt.h matrix.h gpbr.h aes.h pioe.h afec0.h can1.h usart0.h piob.h uart1.h piod.h supc.h rtc.h dmac.h can0.h afec1.h hsmci.h usart1.h gmac.h dacc.h tc2.h uart0.h tc0.h smc.h twi1.h pioa.h rstc.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e8c.h sam4e8e.h sam4e16c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/drivers/usart
    ../../../../usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../uart/: uart.c uart.h
  group sam/drivers/gmac
    ../../../: gmac_raw.c gmac_phy.c gmac.h gmac_raw.h
  group sam/drivers/gmac/unit_tests
    ../../: unit_tests.c mini_ip.h
  group sam/drivers/gmac/unit_tests/sam4e16e_sam4e_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_eth.h conf_test.h
  group sam/drivers/gmac/unit_tests/sam4e16e_sam4e_xplained_pro/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/efc
    ../../../../efc/: efc.c efc.h
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/components/ethernet_phy
    ../../../../../components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../../components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../boards/sam4e_xplained_pro/: init.c sam4e_xplained_pro.h led.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c sysclk.h genclk.h pll.h osc.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
