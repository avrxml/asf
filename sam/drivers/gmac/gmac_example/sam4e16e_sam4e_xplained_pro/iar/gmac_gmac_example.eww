<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gmac_gmac_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\gmac_gmac_example_sram.ewp</path>
	</project>
</workspace>
