<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\lcdca_example_flash.ewp</path>
	</project>
</workspace>
