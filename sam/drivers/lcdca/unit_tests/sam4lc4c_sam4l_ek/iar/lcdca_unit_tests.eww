<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\lcdca_unit_tests_flash.ewp</path>
	</project>
</workspace>
