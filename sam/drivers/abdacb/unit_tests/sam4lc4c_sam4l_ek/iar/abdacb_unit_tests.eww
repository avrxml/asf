<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\abdacb_unit_tests_flash.ewp</path>
	</project>
</workspace>
