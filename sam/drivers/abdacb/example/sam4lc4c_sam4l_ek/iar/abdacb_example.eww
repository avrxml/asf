<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\abdacb_example_flash.ewp</path>
	</project>
</workspace>
