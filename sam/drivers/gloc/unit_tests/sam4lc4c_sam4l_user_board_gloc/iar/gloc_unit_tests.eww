<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gloc_unit_tests_flash.ewp</path>
	</project>
</workspace>
