<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_tc_capture_waveform_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\tc_tc_capture_waveform_example_sram.ewp</path>
	</project>
</workspace>
