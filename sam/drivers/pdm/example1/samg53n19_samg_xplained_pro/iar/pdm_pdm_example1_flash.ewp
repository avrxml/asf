# IAR project pdm_pdm_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../supc; ../../../../pdc/pdc_uart_example; ../../../../../utils/cmsis/samg/samg53/source/templates; ../../../../../utils; ../../../../../utils/cmsis/samg/samg53/include; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../boards/samg53_xplained_pro; ../../../../../utils/fpu; ../../../../../../common/services/ioport; ../../../../pmc; ../../../../pio; ../../..; ..; ../../../../pdc; ../../../../../../common/utils; ../..; ../../../../efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_pdm_example1_flash.bin
  ILINK.IlinkOutputFile: pdm_pdm_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../utils/cmsis/samg/samg53/source/templates/: exceptions.c system_samg53.c system_samg53.h exceptions.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../utils/cmsis/samg/samg53/include/: samg53g19.h samg53.h samg53n19.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../utils/cmsis/samg/samg53/include/instance/: instance_rtc.h instance_tc0.h instance_pdmic0.h instance_pdmic1.h instance_mem2mem.h instance_adc.h instance_usart.h instance_chipid.h instance_piob.h instance_i2sc1.h instance_uart0.h instance_twi2.h instance_rstc.h instance_pioa.h instance_efc.h instance_i2sc0.h instance_spi.h instance_twi0.h instance_uart1.h instance_tc1.h instance_twi1.h instance_supc.h instance_wdt.h instance_pmc.h instance_matrix.h instance_gpbr.h instance_rtt.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../utils/cmsis/samg/samg53/include/pio/: pio_samg53n19.h pio_samg53g19.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../utils/cmsis/samg/samg53/include/component/: component_rtt.h component_i2sc.h component_rstc.h component_usart.h component_pdc.h component_pdmic.h component_spi.h component_rtc.h component_chipid.h component_efc.h component_uart.h component_gpbr.h component_tc.h component_pio.h component_adc.h component_matrix.h component_twi.h component_mem2mem.h component_wdt.h component_pmc.h component_supc.h component_twihs.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/drivers/pdm
    ../../../: pdm.c pdm.h
  group sam/drivers/pdm/example1
    ../../: pdm_example1.c
  group sam/drivers/pdm/example1/samg53n19_samg_xplained_pro
    ../: conf_clock.h conf_board.h conf_example.h
  group sam/drivers/pdm/example1/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/supc
    ../../../../supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../efc/: efc.c efc.h
  group sam/boards/samg53_xplained_pro
    ../../../../../boards/samg53_xplained_pro/: board_init.c led.h samg53_xplained_pro.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
