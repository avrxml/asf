# IAR project tc_qdec_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; __SAM4E16E__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../../../../drivers/pmc; ..; ../../../../utils/fpu; ../../../../../common/services/serial; ../../../../utils/cmsis/sam4e/source/templates; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../utils/cmsis/sam4e/include; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../drivers/uart; ../../../../utils; ../..; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; __SAM4E16E__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tc_qdec_example_flash.bin
  ILINK.IlinkOutputFile: tc_qdec_example_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/applications/tc_qdec_example
    ../../: tc_qdec_example.c
  group sam/applications/tc_qdec_example/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_board.h conf_example.h conf_clock.h
  group sam/applications/tc_qdec_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../utils/cmsis/sam4e/include/: sam4e8c.h sam4e16e.h sam4e8e.h sam4e8cb.h sam4e16c.h sam4e16cb.h sam4e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../utils/cmsis/sam4e/include/instance/: afec0.h matrix.h smc.h spi.h dacc.h udp.h hsmci.h tc2.h acc.h chipid.h rtc.h tc1.h twi0.h can0.h gmac.h uart0.h piod.h rswdt.h pwm.h piob.h pioc.h tc0.h rstc.h dmac.h twi1.h can1.h supc.h uart1.h pioa.h usart1.h efc.h usart0.h wdt.h pioe.h aes.h cmcc.h afec1.h pmc.h gpbr.h rtt.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../utils/cmsis/sam4e/include/component/: dacc.h rswdt.h rtc.h matrix.h supc.h hsmci.h pdc.h smc.h wdt.h gmac.h spi.h dmac.h usart.h udp.h tc.h gpbr.h cmcc.h uart.h can.h efc.h rtt.h rstc.h pio.h pwm.h aes.h chipid.h afec.h acc.h pmc.h twi.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../utils/cmsis/sam4e/include/pio/: sam4e16cb.h sam4e16c.h sam4e8e.h sam4e16e.h sam4e8cb.h sam4e8c.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/boards/sam4e_ek
    ../../../../boards/sam4e_ek/: init.c sam4e_ek.h led.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
