<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_qdec_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\tc_qdec_example_sram.ewp</path>
	</project>
</workspace>
