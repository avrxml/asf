<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\starter_kit_demo_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\starter_kit_demo_sram.ewp</path>
	</project>
</workspace>
