# IAR project sam_toolkit_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; __FREERTOS__; QT_NUM_CHANNELS=32; SNS2=A; DEF_TOUCH_QDEBUG_ENABLE_AT=0; SNSK1=C; SNSK2=A; SNS1=C; QT_DELAY_CYCLES=5; BOARD=SAM4S_EK; QTOUCH_SLIDER_REVERSED; ARM_MATH_CM4=true; DEF_TOUCH_QDEBUG_ENABLE_QTA=0; DEF_TOUCH_QDEBUG_ENABLE_QM=0; _SNS2_SNSK2_SAME_PORT_; ACCESS_USB_ENABLED; _SNS1_SNSK1_SAME_PORT_; UDD_ENABLE; DEF_TOUCH_QDEBUG_ENABLE_QTB=0; CONF_GFX_ILI93XX=1; _QTOUCH_; _DEBUG_INTERFACE_
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../../common/services/spi/sam_spi; ../../../../utils/preprocessor; ../../../../../thirdparty/qtouch/qdebug; ../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../utils/cmsis/sam4s/include; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../drivers/ebi/smc; ../../../../../common/services/gfx; ../../../../../thirdparty/qtouch/generic/include; ../../../../../common/utils/membag; ../../../../../common/services/serial; ../../../../drivers/rtc; ../../../../services/flash_efc; ../../../../drivers/spi; ..; ../../../../drivers/supc; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../drivers/wdt; ../..; ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam; ../../../../../common/services/usb/class/msc/device; ../../../../boards/sam4s_ek; ../../../../components/resistive_touch/ads7843; ../../../../../common/services/clock; ../../../../drivers/matrix; ../../../../components/display/aat31xx; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/components/memory/nand_flash/nand_flash_ebi; ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/pdc/pdc_uart_example; ../../../../drivers/udp; ../../../../drivers/uart; ../../../../../common/services/gpio; ../../../../../common/services/storage/ecc_hamming; ../../../../drivers/pdc; ../../../../utils/cmsis/sam4s/source/templates; ../../../../../common/services/wtk; ../../../../../common/services/delay; ../../../../../thirdparty/qtouch/generic/sam/qtouch/common; ../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../services/resistive_touch; ../../../../../common/services/usb/class/msc; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards; ../../../../components/display/ili93xx; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam_toolkit_demo_flash.bin
  ILINK.IlinkOutputFile: sam_toolkit_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x8000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/lib/iar/: libsam4s-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/common/: BitBangSPI_Master.c BitBangSPI_Master.h touch_qt_config.h
  group thirdparty/qtouch/generic/include
    ../../../../../thirdparty/qtouch/generic/include/: touch_api.h
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug.c QDebugTransport.c QDebug.h QDebugTransport.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/: list.c tasks.c croutine.c queue.c timers.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: task.h projdefs.h croutine.h FreeRTOS.h mpu_wrappers.h queue.h list.h timers.h StackMacros.h semphr.h portable.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c diskio.h integer.h ffconf.h ff.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_spare_scheme.c nand_flash_model.c nand_flash_raw_smc.c nand_flash_common.h nand_flash_spare_scheme.h nand_flash_ecc.h nand_flash_raw.h nand_flash_model.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c nand_flash_translation.h nand_flash_mem.h nand_flash_management.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm4.a
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gfx
    ../../../../../common/services/gfx/: gfx_text.c gfx_generic.c gfx_ili93xx.c sysfont.c gfx_text.h gfx_generic.h gfx.h gfx_ili93xx.h sysfont.h
  group common/services/wtk
    ../../../../../common/services/wtk/: wtk_progress_bar.c wtk_radio_button.c wtk_check_box.c wtk_label.c wtk_icon.c wtk_button.c wtk_slider.c win.c wtk_plot.c wtk_basic_frame.c wtk.c wtk_frame.c wtk_label.h wtk_check_box.h wtk_progress_bar.h wtk_button.h wtk_icon.h wtk_frame.h wtk_radio_button.h wtk_slider.h win.h wtk_plot.h wtk.h wtk_basic_frame.h
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/msc
    ../../../../../common/services/usb/class/msc/: sbc_protocol.h usb_protocol_msc.h spc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../common/services/usb/class/msc/device/: udi_msc_desc.c udi_msc.c udi_msc_conf.h udi_msc.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udd.h udi.h udc_desc.h udc.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/storage/ecc_hamming
    ../../../../../common/services/storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/membag
    ../../../../../common/utils/membag/: membag.c membag.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/applications/sam_toolkit_demo
    ../../: widget_scr_settings_date.c widget_scr_settings_backlight.c widget_scr_qtouch.c widget_scr_main.c widget_scr_lpm_wait.c widget_scr_settings.c widget_scr_lpm.c widget_scr_lpm_sleep.c rtouch_calibrate.c widget_scr_audio.c widget_scr_lpm_backup.c demo_qtouch.c widget_scr_settings_time.c demo_draw_bmpfile.c demo_parameters.c widget_scr_fft.c demo.c widget_scr_info.c bitmaps.h rtouch_calibrate.h demo_parameters.h demo.h
  group sam/applications/sam_toolkit_demo/sam4s16c_sam4s_ek
    ../: demo_board.c conf_demo.h conf_sysfont.h conf_uart_serial.h conf_clock.h conf_board.h conf_membag.h conf_aat31xx.h QDebugSettings.h conf_usb.h conf_spi_master.h conf_wtk.h conf_win.h demo_board.h conf_sleepmgr.h conf_access.h FreeRTOSConfig.h conf_fatfs.h conf_nf.h conf_ili93xx.h conf_ads7843.h
  group sam/applications/sam_toolkit_demo/sam4s16c_sam4s_ek/iar
    ./: asf.h
  group sam/components/resistive_touch/ads7843
    ../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
  group sam/components/display/aat31xx
    ../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/display/ili93xx
    ../../../../components/display/ili93xx/: ili93xx.c ili9341_regs.h ili93xx.h ili9325_regs.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../utils/cmsis/sam4s/include/: sam4s2a.h sam4sa16b.h sam4s2c.h sam4s16b.h sam4sd32c.h sam4sd16b.h sam4s.h sam4sd32b.h sam4sa16c.h sam4s4b.h sam4s8b.h system_sam4s.h sam4sd16c.h sam4s4c.h sam4s4a.h sam4s2b.h sam4s16c.h sam4s8c.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../utils/cmsis/sam4s/include/component/: component_chipid.h component_rstc.h component_twi.h component_uart.h component_wdt.h component_pmc.h component_pdc.h component_udp.h component_pwm.h component_cmcc.h component_smc.h component_gpbr.h component_adc.h component_matrix.h component_ssc.h component_pio.h component_supc.h component_rtc.h component_efc.h component_usart.h component_rtt.h component_spi.h component_tc.h component_crccu.h component_acc.h component_hsmci.h component_dacc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../utils/cmsis/sam4s/include/pio/: pio_sam4s8c.h pio_sam4s2c.h pio_sam4sa16c.h pio_sam4s4c.h pio_sam4sd32b.h pio_sam4s16b.h pio_sam4s2a.h pio_sam4sa16b.h pio_sam4s16c.h pio_sam4sd16b.h pio_sam4s4a.h pio_sam4s2b.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4sd32c.h pio_sam4sd16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../utils/cmsis/sam4s/include/instance/: instance_rstc.h instance_hsmci.h instance_spi.h instance_efc1.h instance_pwm.h instance_rtc.h instance_uart0.h instance_chipid.h instance_tc1.h instance_dacc.h instance_matrix.h instance_udp.h instance_pioc.h instance_pmc.h instance_rtt.h instance_piob.h instance_uart1.h instance_pioa.h instance_supc.h instance_acc.h instance_twi0.h instance_usart0.h instance_adc.h instance_crccu.h instance_wdt.h instance_usart1.h instance_tc0.h instance_gpbr.h instance_twi1.h instance_efc0.h instance_cmcc.h instance_smc.h instance_ssc.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pdc
    ../../../../drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/udp
    ../../../../drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/adc
    ../../../../drivers/adc/: adc_sam3u.c adc.c adc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/matrix
    ../../../../drivers/matrix/: matrix.c matrix.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/rtc
    ../../../../drivers/rtc/: rtc.c rtc.h
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/boards/sam4s_ek
    ../../../../boards/sam4s_ek/: led.c led.h sam4s_ek.h
  group sam/services/resistive_touch
    ../../../../services/resistive_touch/: rtouch.c rtouch.h rtouch_ads7843.h
  group sam/services/flash_efc
    ../../../../services/flash_efc/: flash_efc.c flash_efc.h
