<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_toolkit_demo_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_toolkit_demo_sram.ewp</path>
	</project>
</workspace>
