# IAR project edbg_i2c_info_interface_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_XPLAINED_PRO; __SAM4E16E__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../drivers/twi; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../utils; ..; ../../../../utils/fpu; ../../../../boards; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../boards/sam4e_xplained_pro; ../../../../../common/services/clock; ../../../../../common/services/ioport; ../../../../drivers/pmc; ../../../../utils/cmsis/sam4e/source/templates; ../../../../utils/cmsis/sam4e/include; ../../../../../common/utils; ../..; ../../../../../common/services/serial; ../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_XPLAINED_PRO; __SAM4E16E__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: edbg_i2c_info_interface_flash.bin
  ILINK.IlinkOutputFile: edbg_i2c_info_interface_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/twi
    ../../../../drivers/twi/: twi.c twi.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../utils/cmsis/sam4e/include/: sam4e8c.h sam4e16e.h sam4e8e.h sam4e16c.h sam4e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../utils/cmsis/sam4e/include/instance/: afec0.h matrix.h smc.h spi.h dacc.h pmc.h tc2.h hsmci.h acc.h chipid.h rtc.h tc1.h twi0.h can0.h gmac.h uart0.h piod.h rswdt.h pwm.h piob.h pioc.h tc0.h rstc.h dmac.h twi1.h can1.h supc.h uart1.h pioa.h usart1.h efc.h udp.h usart0.h wdt.h pioe.h aes.h cmcc.h afec1.h gpbr.h rtt.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../utils/cmsis/sam4e/include/component/: dacc.h rswdt.h rtc.h matrix.h supc.h hsmci.h pdc.h smc.h wdt.h gmac.h spi.h dmac.h usart.h udp.h tc.h gpbr.h cmcc.h uart.h can.h efc.h rtt.h rstc.h pio.h pwm.h aes.h chipid.h afec.h acc.h pmc.h twi.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../utils/cmsis/sam4e/include/pio/: sam4e16c.h sam4e8e.h sam4e16e.h sam4e8c.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/applications/edbg_twi_information_interface
    ../../: main.c
  group sam/applications/edbg_twi_information_interface/sam4e16e_sam4e_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_clock.h
  group sam/applications/edbg_twi_information_interface/sam4e16e_sam4e_xplained_pro/iar
    ./: asf.h
  group sam/boards/sam4e_xplained_pro
    ../../../../boards/sam4e_xplained_pro/: init.c led.h sam4e_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
