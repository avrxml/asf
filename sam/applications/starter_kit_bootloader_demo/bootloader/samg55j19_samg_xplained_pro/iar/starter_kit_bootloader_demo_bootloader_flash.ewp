# IAR project starter_kit_bootloader_demo_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; SD_MMC_ENABLE; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../common/components/memory/sd_mmc; ../../../../../utils/header_files; ../../../../../../common/services/spi/sam_spi; ..; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../drivers/flexcom; ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../boards/samg55_xplained_pro; ../../../../../drivers/efc; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../..; ../../../../../services/flash_efc; ../../../../../drivers/spi; ../../../../../drivers/supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../utils/cmsis/samg/samg55/source/templates; ../../../../../drivers/wdt; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/ioport; ../../../../../../common/services/delay; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../drivers/rtc; ../../../../../drivers/pio; ../../../../../utils/cmsis/samg/samg55/include; ../../../../../../common/services/spi; ../../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: starter_kit_bootloader_demo_bootloader_flash.bin
  ILINK.IlinkOutputFile: starter_kit_bootloader_demo_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../utils/cmsis/samg/samg55/include/: samg55g18.h samg55j19.h samg55.h system_samg55.h samg55g19.h samg55j18.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../utils/cmsis/samg/samg55/include/instance/: tc0.h piob.h flexcom0.h chipid.h flexcom2.h usart0.h wdt.h usart6.h i2sc1.h pdmic1.h supc.h rstc.h spi1.h pmc.h rtt.h gpbr.h flexcom4.h flexcom3.h cmcc.h efc.h i2sc0.h crccu.h pdmic0.h twi0.h spi4.h flexcom7.h flexcom1.h spi0.h pioa.h flexcom5.h usart2.h usart5.h rtc.h spi2.h spi5.h twi4.h twi6.h adc.h spi7.h mem2mem.h twi2.h twi1.h usart4.h tc1.h usart1.h usart3.h matrix.h spi3.h usart7.h udp.h flexcom6.h twi5.h twi7.h spi6.h uhp.h twi3.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../utils/cmsis/samg/samg55/include/component/: gpbr.h twi.h wdt.h usart.h rtc.h udp.h adc.h pio.h cmcc.h crccu.h mem2mem.h rstc.h i2sc.h supc.h matrix.h flexcom.h uhp.h chipid.h tc.h pmc.h pdmic.h pdc.h efc.h rtt.h spi.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55g18.h samg55j19.h samg55n19.h samg55j18.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/wdt
    ../../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/rtc
    ../../../../../drivers/rtc/: rtc.c rtc.h
  group sam/drivers/flexcom
    ../../../../../drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/supc
    ../../../../../drivers/supc/: supc.c supc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group sam/applications/starter_kit_bootloader_demo/bootloader
    ../../: regions.c trigger.c bootloader.c media.c debug_usart.c memory_flash.c media_sd.c conf_fatfs.h conf_access.h media.h memories.h regions.h trigger.h bootloader.h debug.h
  group sam/applications/starter_kit_bootloader_demo/bootloader/samg55j19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_bootloader.h conf_sleepmgr.h conf_spi_master.h conf_sd_mmc.h
  group sam/applications/starter_kit_bootloader_demo/bootloader/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/sd_mmc
    ../../../../../../common/components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_spi.c sd_mmc.h sd_mmc_spi.h sd_mmc_mem.h sd_mmc_protocol.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/storage/ctrl_access
    ../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c integer.h ff.h diskio.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
