# IAR project starter_kit_bootloader_demo_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SD_MMC_ENABLE; ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../common/components/memory/sd_mmc; ../../../../../utils/cmsis/sam4n/include; ../../../../../../common/services/spi/sam_spi; ../../../../../boards/sam4n_xplained_pro; ../../../../../utils/cmsis/sam4n/source/templates; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../utils/header_files; ../../../../../drivers/efc; ../../../../../../common/services/serial; ../..; ../../../../../services/flash_efc; ..; ../../../../../../common/utils; ../../../../../drivers/spi; ../../../../../drivers/wdt; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/ioport; ../../../../../../common/services/delay; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../drivers/rtc; ../../../../../drivers/pio; ../../../../../../common/services/spi; ../../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: starter_kit_bootloader_demo_bootloader_flash.bin
  ILINK.IlinkOutputFile: starter_kit_bootloader_demo_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/sd_mmc
    ../../../../../../common/components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_spi.c sd_mmc.h sd_mmc_spi.h sd_mmc_mem.h sd_mmc_protocol.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/storage/ctrl_access
    ../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4n
    ../../../../../../common/services/clock/sam4n/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c integer.h ff.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/wdt
    ../../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/rtc
    ../../../../../drivers/rtc/: rtc.c rtc.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/applications/starter_kit_bootloader_demo/bootloader
    ../../: regions.c trigger.c bootloader.c media.c debug_usart.c memory_flash.c media_sd.c conf_fatfs.h media.h memories.h regions.h conf_access.h trigger.h bootloader.h debug.h
  group sam/applications/starter_kit_bootloader_demo/bootloader/sam4n16c_sam4n_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_bootloader.h conf_spi_master.h conf_sd_mmc.h
  group sam/applications/starter_kit_bootloader_demo/bootloader/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../utils/cmsis/sam4n/source/templates/: system_sam4n.c exceptions.c system_sam4n.h exceptions.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../utils/cmsis/sam4n/include/: sam4n16b.h sam4n.h sam4n16c.h sam4n8c.h sam4n8a.h sam4n8b.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../utils/cmsis/sam4n/include/instance/: instance_efc.h instance_matrix.h instance_rstc.h instance_usart2.h instance_pwm.h instance_twi2.h instance_supc.h instance_usart1.h instance_piob.h instance_usart0.h instance_adc.h instance_tc1.h instance_twi0.h instance_dacc.h instance_uart3.h instance_pioa.h instance_wdt.h instance_gpbr.h instance_uart2.h instance_pmc.h instance_pioc.h instance_twi1.h instance_tc0.h instance_rtt.h instance_uart0.h instance_uart1.h instance_spi.h instance_chipid.h instance_rtc.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../utils/cmsis/sam4n/include/pio/: pio_sam4n8b.h pio_sam4n16b.h pio_sam4n16c.h pio_sam4n8c.h pio_sam4n8a.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../utils/cmsis/sam4n/include/component/: component_rtt.h component_wdt.h component_usart.h component_chipid.h component_efc.h component_pdc.h component_spi.h component_twi.h component_pio.h component_gpbr.h component_tc.h component_adc.h component_dacc.h component_pmc.h component_pwm.h component_matrix.h component_rstc.h component_supc.h component_uart.h component_rtc.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
