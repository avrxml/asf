# IAR project sam4s_xplained_qtouch_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; SNSK1=A; ARM_MATH_CM4=true; __SAM4S16C__; SNS1=A; QT_DELAY_CYCLES=3; _QTOUCH_; QT_NUM_CHANNELS=32; _DEBUG_INTERFACE_; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ..; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam4s/include; ../../../../../thirdparty/qtouch/generic/include; ../../../../../common/services/serial; ../../../../../thirdparty/qtouch/qdebug; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../thirdparty/qtouch/generic/sam/qtouch/common; ../../../../../common/services/gpio; ../../../../utils/cmsis/sam4s/source/templates; ../../../../drivers/uart; ../../../../utils; ../..; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../drivers/pio; ../../../../boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4s_xplained_qtouch_demo_flash.bin
  ILINK.IlinkOutputFile: sam4s_xplained_qtouch_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/lib/iar/: libsam4s-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/common/: BitBangSPI_Master.c BitBangSPI_Master.h touch_qt_config.h
  group thirdparty/qtouch/generic/include
    ../../../../../thirdparty/qtouch/generic/include/: touch_api.h
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug.c QDebugTransport.c QDebug.h QDebugTransport.h
  group sam/applications/sam4s_xplained_qtouch_demo
    ../../: qtouch_demo.c
  group sam/applications/sam4s_xplained_qtouch_demo/sam4s16c_sam4s_xplained
    ../: conf_uart_serial.h QDebugSettings.h conf_board.h conf_example.h conf_clock.h
  group sam/applications/sam4s_xplained_qtouch_demo/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/boards/sam4s_xplained
    ../../../../boards/sam4s_xplained/: led.c sam4s_xplained.h led.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../utils/cmsis/sam4s/include/: sam4s2a.h sam4sa16b.h sam4s2c.h sam4s16b.h sam4sd32c.h sam4sa16c.h sam4sd16c.h sam4sd16b.h sam4s.h sam4s8b.h sam4sd32b.h sam4s4b.h system_sam4s.h sam4s4c.h sam4s4a.h sam4s2b.h sam4s16c.h sam4s8c.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../utils/cmsis/sam4s/include/component/: component_chipid.h component_matrix.h component_rstc.h component_twi.h component_uart.h component_wdt.h component_pmc.h component_pdc.h component_udp.h component_pwm.h component_cmcc.h component_smc.h component_gpbr.h component_adc.h component_ssc.h component_dacc.h component_pio.h component_supc.h component_rtc.h component_efc.h component_usart.h component_rtt.h component_spi.h component_tc.h component_crccu.h component_acc.h component_hsmci.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../utils/cmsis/sam4s/include/pio/: pio_sam4s8c.h pio_sam4s2c.h pio_sam4sa16c.h pio_sam4s4c.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4s16b.h pio_sam4sa16b.h pio_sam4sd16b.h pio_sam4s4a.h pio_sam4s16c.h pio_sam4s2b.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4sd32c.h pio_sam4sd16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../utils/cmsis/sam4s/include/instance/: instance_rstc.h instance_hsmci.h instance_smc.h instance_pwm.h instance_rtc.h instance_uart0.h instance_efc1.h instance_tc1.h instance_dacc.h instance_chipid.h instance_matrix.h instance_uart1.h instance_pioc.h instance_spi.h instance_usart1.h instance_piob.h instance_crccu.h instance_tc0.h instance_supc.h instance_rtt.h instance_acc.h instance_gpbr.h instance_twi0.h instance_usart0.h instance_adc.h instance_pioa.h instance_wdt.h instance_pmc.h instance_udp.h instance_twi1.h instance_efc0.h instance_cmcc.h instance_ssc.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
