<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam4l_host_msc_boot_aes_fw_gen_flash.ewp</path>
	</project>
</workspace>
