# IAR project sam4l_host_msc_boot_aes_fw_gen_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; __SAM4LC4C__; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../drivers/usbc; ../..; ../../../../../../common/services/usb/class/msc; ../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../utils/cmsis/sam4l/include; ../../../../../utils/cmsis/sam4l/source/templates; ..; ../../../../../drivers/ast; ../../../../../drivers/eic; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../drivers/aesa; ../../../../../drivers/wdt; ../../../../../../common/services/usb/uhc; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../utils/preprocessor; ../../../../../../common/services/usb; ../../../../../drivers/gpio; ../../../../../../common/services/usb/class/msc/host; ../../../../../utils; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../drivers/flashcalw; ../../../../../../common/boards; ../../../../../boards/sam4l_xplained_pro; ../../../../../../common/services/ioport; ../../../../../drivers/crccu; ../../../../../drivers/bpm; ../../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4l_host_msc_boot_aes_fw_gen_flash.bin
  ILINK.IlinkOutputFile: sam4l_host_msc_boot_aes_fw_gen_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c integer.h ff.h diskio.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_ast.c
  group sam/drivers/gpio
    ../../../../../drivers/gpio/: gpio.c gpio.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/eic
    ../../../../../drivers/eic/: eic.c eic.h
  group sam/drivers/wdt
    ../../../../../drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/ast
    ../../../../../drivers/ast/: ast.c ast.h
  group sam/drivers/usbc
    ../../../../../drivers/usbc/: usbc_host.c usbc_otg.h usbc_host.h
  group sam/drivers/flashcalw
    ../../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/crccu
    ../../../../../drivers/crccu/: crccu.c crccu.h
  group sam/drivers/bpm
    ../../../../../drivers/bpm/: bpm.c bpm.h
  group sam/drivers/aesa
    ../../../../../drivers/aesa/: aesa.c aesa.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../utils/cmsis/sam4l/include/: sam4lc4c.h sam4lc8a.h sam4lc8c.h sam4lc2b.h sam4lc2a.h sam4ls4b.h sam4ls2b.h sam4ls8b.h sam4ls4c.h sam4ls2a.h sam4ls2c.h sam4ls8c.h sam4ls8a.h sam4lc2c.h sam4l.h sam4ls4a.h sam4lc4b.h sam4lc4a.h sam4lc8b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../utils/cmsis/sam4l/include/instance/: instance_eic.h instance_twim2.h instance_smap.h instance_trng.h instance_wdt.h instance_dacc.h instance_crccu.h instance_usart0.h instance_twis0.h instance_usart1.h instance_gloc.h instance_chipid.h instance_tc1.h instance_catb.h instance_ast.h instance_bscif.h instance_scif.h instance_usart3.h instance_abdacb.h instance_usbc.h instance_freqm.h instance_gpio.h instance_hcache.h instance_tc0.h instance_pm.h instance_twim3.h instance_twim1.h instance_hmatrix.h instance_twis1.h instance_parc.h instance_iisc.h instance_bpm.h instance_usart2.h instance_adcife.h instance_picouart.h instance_aesa.h instance_spi.h instance_pevc.h instance_twim0.h instance_pdca.h instance_hflashc.h instance_acifc.h instance_lcdca.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../utils/cmsis/sam4l/include/component/: component_crccu.h component_dacc.h component_twim.h component_bpm.h component_ast.h component_wdt.h component_lcdca.h component_chipid.h component_adcife.h component_aesa.h component_smap.h component_flashcalw.h component_trng.h component_pevc.h component_spi.h component_parc.h component_gpio.h component_freqm.h component_pm.h component_acifc.h component_gloc.h component_twis.h component_pdca.h component_picouart.h component_tc.h component_scif.h component_hcache.h component_iisc.h component_usart.h component_bscif.h component_usbc.h component_eic.h component_catb.h component_hmatrixb.h component_abdacb.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../utils/cmsis/sam4l/include/pio/: pio_sam4ls4b.h pio_sam4ls8a.h pio_sam4ls8c.h pio_sam4lc8b.h pio_sam4ls2b.h pio_sam4ls4c.h pio_sam4lc8a.h pio_sam4lc8c.h pio_sam4ls8b.h pio_sam4lc2b.h pio_sam4lc4b.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls2a.h pio_sam4lc2a.h pio_sam4lc2c.h pio_sam4lc4a.h pio_sam4lc4c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
  group sam/applications/sam4l_host_msc_aes_bootloader/firmware_generator
    ../../: main.c main.h
  group sam/applications/sam4l_host_msc_aes_bootloader/firmware_generator/sam4lc4c_sam4l_xplained_pro
    ../: conf_ast.h conf_bootloader.h conf_aesa.h conf_clock.h conf_board.h conf_sleepmgr.h conf_access.h conf_usb_host.h conf_fatfs.h
  group sam/applications/sam4l_host_msc_aes_bootloader/firmware_generator/sam4lc4c_sam4l_xplained_pro/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: pll.c osc.c sysclk.c dfll.c pll.h dfll.h sysclk.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/storage/ctrl_access
    ../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/uhc
    ../../../../../../common/services/usb/uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/services/usb/class/msc
    ../../../../../../common/services/usb/class/msc/: usb_protocol_msc.h sbc_protocol.h spc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../../common/services/usb/class/msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
