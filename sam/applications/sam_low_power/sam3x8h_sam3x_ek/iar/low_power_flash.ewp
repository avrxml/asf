# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../boards/sam3x_ek; ../../../../utils/cmsis/sam3x/source/templates; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../utils/cmsis/sam3x/include; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ..; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../utils/cmsis/sam3x/include/: sam3a8c.h sam3a4c.h sam3x8e.h sam3xa.h sam3x8h.h sam3x8c.h sam3x4e.h sam3x4c.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../utils/cmsis/sam3x/include/component/: component_matrix.h component_twi.h component_supc.h component_uart.h component_spi.h component_tc.h component_pdc.h component_hsmci.h component_pmc.h component_dacc.h component_rtc.h component_uotghs.h component_ssc.h component_chipid.h component_pwm.h component_usart.h component_rstc.h component_gpbr.h component_pio.h component_smc.h component_dmac.h component_rtt.h component_trng.h component_efc.h component_wdt.h component_sdramc.h component_adc.h component_can.h component_emac.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../utils/cmsis/sam3x/include/instance/: instance_smc.h instance_pioe.h instance_rtc.h instance_efc1.h instance_rstc.h instance_dmac.h instance_pioa.h instance_emac.h instance_uotghs.h instance_usart1.h instance_ssc.h instance_usart3.h instance_piob.h instance_tc0.h instance_uart.h instance_twi1.h instance_sdramc.h instance_piof.h instance_tc2.h instance_trng.h instance_rtt.h instance_spi0.h instance_usart0.h instance_usart2.h instance_piod.h instance_pioc.h instance_dacc.h instance_wdt.h instance_supc.h instance_can0.h instance_pmc.h instance_twi0.h instance_spi1.h instance_adc.h instance_tc1.h instance_chipid.h instance_hsmci.h instance_pwm.h instance_matrix.h instance_efc0.h instance_can1.h instance_gpbr.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../utils/cmsis/sam3x/include/pio/: pio_sam3x8c.h pio_sam3x8e.h pio_sam3a4c.h pio_sam3x4c.h pio_sam3a8c.h pio_sam3x4e.h pio_sam3x8h.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam3x8h_sam3x_ek
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group sam/boards/sam3x_ek
    ../../../../boards/sam3x_ek/: led.c init.c led.h sam3x_ek.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
