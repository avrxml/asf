# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../boards/sam4e_xplained_pro; ../../../../drivers/pmc; ..; ../../../../drivers/efc; ../../../../utils/fpu; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../utils/cmsis/sam4e/source/templates; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../drivers/matrix; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../utils/cmsis/sam4e/include; ../../../../drivers/uart; ../../../../drivers/rtt; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/matrix
    ../../../../drivers/matrix/: matrix.c matrix.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/rtt
    ../../../../drivers/rtt/: rtt.c rtt.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../utils/cmsis/sam4e/include/: sam4e8c.h sam4e16e.h sam4e8e.h sam4e16c.h sam4e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../utils/cmsis/sam4e/include/instance/: afec0.h matrix.h smc.h spi.h dacc.h pmc.h hsmci.h tc2.h acc.h chipid.h rtc.h tc1.h twi0.h can0.h gmac.h uart0.h piod.h rswdt.h pwm.h piob.h pioc.h tc0.h rstc.h dmac.h twi1.h can1.h supc.h uart1.h pioa.h usart1.h efc.h udp.h usart0.h crccu.h wdt.h pioe.h aes.h cmcc.h afec1.h gpbr.h rtt.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../utils/cmsis/sam4e/include/component/: dacc.h rswdt.h rtc.h matrix.h supc.h hsmci.h pdc.h smc.h wdt.h gmac.h spi.h dmac.h usart.h udp.h tc.h gpbr.h cmcc.h uart.h can.h crccu.h efc.h rtt.h rstc.h pio.h pwm.h aes.h chipid.h afec.h acc.h pmc.h twi.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../utils/cmsis/sam4e/include/pio/: sam4e16c.h sam4e8e.h sam4e16e.h sam4e8c.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam4e16e_sam4e_xplained_pro
    ../: low_power_board.c conf_uart_serial.h conf_board.h low_power_board.h conf_clock.h
  group sam/applications/sam_low_power/sam4e16e_sam4e_xplained_pro/iar
    ./: asf.h
  group sam/boards/sam4e_xplained_pro
    ../../../../boards/sam4e_xplained_pro/: init.c led.h sam4e_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
