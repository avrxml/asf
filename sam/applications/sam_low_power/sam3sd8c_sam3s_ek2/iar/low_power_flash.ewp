# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../../common/services/clock; ..; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../utils/cmsis/sam3s8/source/templates; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards/sam3s_ek2; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c exceptions.h system_sam3sd8.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../utils/cmsis/sam3s8/include/: sam3s8.h sam3sd8b.h sam3sd8c.h sam3s8b.h sam3s8c.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../utils/cmsis/sam3s8/include/instance/: instance_pmc.h instance_adc.h instance_efc.h instance_crccu.h instance_pwm.h instance_usart0.h instance_rstc.h instance_rtc.h instance_acc.h instance_matrix.h instance_uart0.h instance_spi.h instance_twi1.h instance_smc.h instance_udp.h instance_tc1.h instance_dacc.h instance_wdt.h instance_rtt.h instance_twi0.h instance_chipid.h instance_usart1.h instance_piob.h instance_supc.h instance_hsmci.h instance_pioc.h instance_ssc.h instance_gpbr.h instance_uart1.h instance_pioa.h instance_tc0.h instance_usart2.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../utils/cmsis/sam3s8/include/component/: component_pwm.h component_smc.h component_twi.h component_chipid.h component_ssc.h component_pdc.h component_crccu.h component_gpbr.h component_usart.h component_efc.h component_hsmci.h component_rstc.h component_uart.h component_wdt.h component_supc.h component_rtc.h component_dacc.h component_rtt.h component_tc.h component_acc.h component_adc.h component_pmc.h component_spi.h component_udp.h component_matrix.h component_pio.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../utils/cmsis/sam3s8/include/pio/: pio_sam3sd8b.h pio_sam3s8b.h pio_sam3s8c.h pio_sam3sd8c.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam3sd8c_sam3s_ek2
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group sam/boards/sam3s_ek2
    ../../../../boards/sam3s_ek2/: init.c led.c sam3s_ek2.h led.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
