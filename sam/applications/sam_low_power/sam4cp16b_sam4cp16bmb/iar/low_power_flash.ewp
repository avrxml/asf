# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../utils/cmsis/sam4cp/source/templates; ../../../../utils/cmsis/sam4cp/include; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ..; ../../../../drivers/supc; ../../../../../common/utils; ../../../../boards/sam4cp16bmb; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/applications/sam_low_power
    ../../: main_sam4cp.c
  group sam/applications/sam_low_power/sam4cp16b_sam4cp16bmb
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../utils/cmsis/sam4cp/include/: sam4cp_1.h sam4cp16b_0.h sam4cp_0.h system_sam4cp.h sam4cp16b_1.h sam4cp.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../utils/cmsis/sam4cp/include/instance/: instance_uart0.h instance_pioc.h instance_matrix1.h instance_icm.h instance_supc.h instance_rtc.h instance_usart0.h instance_spi0.h instance_ipc1.h instance_tc0.h instance_efc.h instance_twi1.h instance_smc1.h instance_pioa.h instance_usart4.h instance_uart1.h instance_rswdt.h instance_spi1.h instance_matrix0.h instance_usart1.h instance_rtt.h instance_aes.h instance_smc0.h instance_usart3.h instance_gpbr.h instance_trng.h instance_pmc.h instance_cmcc0.h instance_adc.h instance_slcdc.h instance_rstc.h instance_wdt.h instance_pwm.h instance_tc1.h instance_cmcc1.h instance_piob.h instance_usart2.h instance_ipc0.h instance_chipid.h instance_twi0.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../utils/cmsis/sam4cp/include/component/: component_rstc.h component_rtc.h component_usart.h component_rswdt.h component_supc.h component_pmc.h component_twi.h component_chipid.h component_matrix.h component_trng.h component_adc.h component_wdt.h component_ipc.h component_smc.h component_spi.h component_tc.h component_cmcc.h component_uart.h component_icm.h component_pdc.h component_slcdc.h component_rtt.h component_aes.h component_pwm.h component_pio.h component_efc.h component_gpbr.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/boards/sam4cp16bmb
    ../../../../boards/sam4cp16bmb/: init.c led.h sam4cp16bmb.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4cp
    ../../../../../common/services/clock/sam4cp/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
