# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/cmsis/sam3u/source/templates; ../../../../utils/preprocessor; ../..; ../../../../drivers/pio; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards/sam3u_ek; ../../../../utils/cmsis/sam3u/include; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/boards/sam3u_ek
    ../../../../boards/sam3u_ek/: init.c led.c sam3u_ek.h led.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam3u4e_sam3u_ek
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../utils/cmsis/sam3u/include/: sam3u4e.h sam3u1e.h sam3u4c.h sam3u.h sam3u2c.h sam3u1c.h sam3u2e.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../utils/cmsis/sam3u/include/component/: component_hsmci.h component_rtc.h component_supc.h component_twi.h component_matrix.h component_spi.h component_efc.h component_adc.h component_rstc.h component_udphs.h component_adc12b.h component_pio.h component_ssc.h component_wdt.h component_tc.h component_usart.h component_dmac.h component_rtt.h component_uart.h component_chipid.h component_pwm.h component_gpbr.h component_pdc.h component_smc.h component_pmc.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../utils/cmsis/sam3u/include/instance/: instance_spi.h instance_usart3.h instance_tc0.h instance_usart2.h instance_efc1.h instance_adc12b.h instance_smc.h instance_pioc.h instance_usart0.h instance_chipid.h instance_ssc.h instance_rstc.h instance_rtt.h instance_matrix.h instance_usart1.h instance_efc0.h instance_twi1.h instance_udphs.h instance_pwm.h instance_piob.h instance_pmc.h instance_uart.h instance_wdt.h instance_twi0.h instance_adc.h instance_rtc.h instance_dmac.h instance_hsmci.h instance_pioa.h instance_gpbr.h instance_supc.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../utils/cmsis/sam3u/include/pio/: pio_sam3u4c.h pio_sam3u2e.h pio_sam3u2c.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u4e.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam3u
    ../../../../../common/services/clock/sam3u/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
