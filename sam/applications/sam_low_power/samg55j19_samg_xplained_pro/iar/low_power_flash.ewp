# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ..; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/flexcom; ../../../../boards/samg55_xplained_pro; ../../../../drivers/efc; ../../../../utils/fpu; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../drivers/supc; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../utils/cmsis/samg/samg55/source/templates; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../utils/cmsis/samg/samg55/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/flexcom
    ../../../../drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../utils/cmsis/samg/samg55/include/: samg55n19.h samg55j19.h samg55.h samg55g18.h system_samg55.h samg55g19.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55j18.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../utils/cmsis/samg/samg55/include/component/: spi.h pmc.h adc.h tc.h efc.h crccu.h flexcom.h twi.h chipid.h cmcc.h rtt.h matrix.h supc.h rstc.h wdt.h usart.h gpbr.h mem2mem.h rtc.h pdc.h uhp.h udp.h i2sc.h pdmic.h pio.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../utils/cmsis/samg/samg55/include/instance/: spi3.h i2sc1.h usart0.h piob.h usart4.h flexcom7.h spi7.h flexcom0.h usart6.h spi5.h flexcom1.h spi1.h pdmic1.h usart2.h supc.h adc.h rtc.h spi2.h usart1.h flexcom3.h spi4.h usart7.h wdt.h tc0.h flexcom2.h twi1.h spi0.h pioa.h usart3.h twi3.h spi6.h rstc.h usart5.h gpbr.h cmcc.h chipid.h mem2mem.h twi4.h twi7.h flexcom5.h tc1.h twi0.h pmc.h crccu.h twi2.h twi5.h i2sc0.h efc.h matrix.h flexcom4.h rtt.h udp.h flexcom6.h pdmic0.h uhp.h twi6.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/boards/samg55_xplained_pro
    ../../../../boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/samg55j19_samg_xplained_pro
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h low_power_board.h
  group sam/applications/sam_low_power/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samg
    ../../../../../common/services/clock/samg/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
