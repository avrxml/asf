# IAR project sam4l_qtouch_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true; _QTOUCH_
  ICCARM.CCIncludePath2: ../../../../drivers/lcdca; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../../thirdparty/qtouch/qdebug; ../../../../drivers/pdca; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/include; ../../../../utils/cmsis/sam4l/include; ../../../../utils/cmsis/sam4l/source/templates; ..; ../../../../drivers/ast; ../../qtouch; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/sam4l_ek; ../../../../drivers/eic; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/services/delay; ../../../../utils; ../../../../components/display/c42364a; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../drivers/flashcalw; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common; ../../../../../common/services/ioport; ../../../../drivers/bpm; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true; _QTOUCH_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4l_qtouch_demo_flash.bin
  ILINK.IlinkOutputFile: sam4l_qtouch_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar/: libsam4l-qt-iar.a
  group thirdparty/qtouch/devspecific/sam4/sam4l/common
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common/: BitBangSPI_Master.c BitBangSPI_Master.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/include
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/include/: touch_api_sam4l.h
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug_sam4l.c QDebugTransport.c QDebug_sam4l.h QDebugTransport.h
  group common/services/clock
    ../../../../../common/services/clock/: pll.h genclk.h osc.h dfll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../common/services/clock/sam4l/: dfll.c sysclk.c pll.c osc.c dfll.h sysclk.h pll.h genclk.h osc.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../utils/cmsis/sam4l/include/: sam4l_patch_asf.h sam4l.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/drivers/lcdca
    ../../../../drivers/lcdca/: lcdca.c lcdca.h
  group sam/drivers/eic
    ../../../../drivers/eic/: eic.c eic.h
  group sam/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group sam/drivers/ast
    ../../../../drivers/ast/: ast.c ast.h
  group sam/drivers/flashcalw
    ../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/bpm
    ../../../../drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/components/display/c42364a
    ../../../../components/display/c42364a/: c42364a.c c42364a.h
  group sam/boards/sam4l_ek
    ../../../../boards/sam4l_ek/: board_monitor.c init.c led.h board_monitor.h sam4l_ek.h
  group sam/applications/sam4l_qtouch_demo
    ../../: app.c ui.c event.c main.c event.h app.h ui.h
  group sam/applications/sam4l_qtouch_demo/qtouch
    ../../qtouch/: touch.c QDebugSettings.h touch_config_sam4l.h
  group sam/applications/sam4l_qtouch_demo/sam4lc4c_sam4l_ek
    ../: conf_board.h conf_ast.h conf_lcdca.h conf_sleepmgr.h conf_c42364a.h conf_clock.h
  group sam/applications/sam4l_qtouch_demo/sam4lc4c_sam4l_ek/iar
    ./: asf.h
