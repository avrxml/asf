# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../../../../drivers/pmc; ..; ../../../../utils/fpu; ../../../../../common/services/serial; ../../../../drivers/mpu; ../../../../../common/utils; ../../../../utils/cmsis/samv71/source/templates; ../../../../boards/samv71_xplained_ultra; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/matrix; ../..; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/mpu
    ../../../../drivers/mpu/: mpu.c mpu.h
  group sam/drivers/matrix
    ../../../../drivers/matrix/: matrix.c matrix.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../utils/cmsis/samv71/include/: samv71j21.h samv71n20.h samv71n21.h samv71q21.h samv71q20.h samv71j19.h samv71q19b.h samv71n19.h samv71j21b.h samv71n19b.h samv71q20b.h samv71j20.h samv71j19b.h samv71n21b.h samv71q21b.h samv71.h samv71j20b.h samv71q19.h samv71n20b.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../utils/cmsis/samv71/include/instance/: icm.h gmac.h tc3.h tc0.h smc.h tc2.h mlb.h usart0.h twihs0.h acc.h gpbr.h twihs2.h usart1.h pwm0.h trng.h utmi.h qspi.h chipid.h rtt.h tc1.h usbhs.h matrix.h afec0.h efc.h pioe.h twihs1.h rtc.h mcan1.h supc.h sdramc.h pwm1.h rswdt.h spi1.h xdmac.h rstc.h pioc.h aes.h i2sc0.h ssc.h isi.h uart1.h uart2.h pioa.h hsmci.h afec1.h dacc.h uart3.h mcan0.h pmc.h wdt.h spi0.h piob.h i2sc1.h piod.h uart4.h uart0.h usart2.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../utils/cmsis/samv71/include/component/: mlb.h ssc.h rstc.h gpbr.h acc.h tc.h pio.h pwm.h usart.h hsmci.h icm.h twihs.h dacc.h uart.h usbhs.h i2sc.h gmac.h sdramc.h matrix.h isi.h aes.h rtt.h supc.h spi.h rswdt.h pmc.h mcan.h efc.h wdt.h trng.h xdmac.h rtc.h qspi.h smc.h utmi.h afec.h chipid.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../utils/cmsis/samv71/include/pio/: samv71j19b.h samv71n19b.h samv71n21b.h samv71q19b.h samv71n20.h samv71q21.h samv71j20.h samv71q21b.h samv71n20b.h samv71j21.h samv71j19.h samv71q19.h samv71j21b.h samv71q20b.h samv71n19.h samv71j20b.h samv71n21.h samv71q20.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/boards/samv71_xplained_ultra
    ../../../../boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group sam/applications/getting-started
    ../../: main.c
  group sam/applications/getting-started/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/applications/getting-started/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samv71
    ../../../../../common/services/clock/samv71/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
