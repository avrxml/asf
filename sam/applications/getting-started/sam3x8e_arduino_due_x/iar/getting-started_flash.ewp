# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ..; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam3x/source/templates; ../../../../../common/services/serial; ../../../../utils/cmsis/sam3x/include; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../../common/services/gpio; ../..; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards/arduino_due_x; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../utils/cmsis/sam3x/include/: sam3a8c.h sam3a4c.h sam3x8e.h sam3xa.h sam3x8h.h sam3x8c.h sam3x4e.h sam3x4c.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../utils/cmsis/sam3x/include/component/: component_matrix.h component_twi.h component_supc.h component_uart.h component_spi.h component_tc.h component_pdc.h component_hsmci.h component_pmc.h component_dacc.h component_rtc.h component_uotghs.h component_ssc.h component_chipid.h component_pwm.h component_usart.h component_rstc.h component_gpbr.h component_pio.h component_smc.h component_dmac.h component_rtt.h component_trng.h component_efc.h component_wdt.h component_sdramc.h component_adc.h component_can.h component_emac.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../utils/cmsis/sam3x/include/instance/: instance_smc.h instance_pioe.h instance_rtc.h instance_efc1.h instance_rstc.h instance_dmac.h instance_matrix.h instance_pioa.h instance_emac.h instance_uotghs.h instance_usart1.h instance_ssc.h instance_usart3.h instance_piob.h instance_tc0.h instance_uart.h instance_twi1.h instance_sdramc.h instance_piof.h instance_tc2.h instance_trng.h instance_rtt.h instance_spi0.h instance_usart0.h instance_usart2.h instance_piod.h instance_pioc.h instance_dacc.h instance_wdt.h instance_supc.h instance_can0.h instance_pmc.h instance_twi0.h instance_spi1.h instance_adc.h instance_tc1.h instance_hsmci.h instance_pwm.h instance_efc0.h instance_can1.h instance_chipid.h instance_gpbr.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../utils/cmsis/sam3x/include/pio/: pio_sam3x8c.h pio_sam3x8e.h pio_sam3a4c.h pio_sam3x4c.h pio_sam3a8c.h pio_sam3x4e.h pio_sam3x8h.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/boards/arduino_due_x
    ../../../../boards/arduino_due_x/: init.c arduino_due_x.h
  group sam/applications/getting-started
    ../../: main.c
  group sam/applications/getting-started/sam3x8e_arduino_due_x
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/applications/getting-started/sam3x8e_arduino_due_x/iar
    ./: asf.h
