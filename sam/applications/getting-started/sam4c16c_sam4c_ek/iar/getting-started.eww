<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\getting-started_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\getting-started_sram.ewp</path>
	</project>
</workspace>
