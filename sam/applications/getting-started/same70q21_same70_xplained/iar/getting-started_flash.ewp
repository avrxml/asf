# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../../../../utils/cmsis/same70/source/templates; ../../../../drivers/pmc; ../../../../utils/cmsis/same70/include; ../../../../utils/fpu; ../../../../../common/services/serial; ../../../../drivers/mpu; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards/same70_xplained; ../../../../drivers/matrix; ..; ../..; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/mpu
    ../../../../drivers/mpu/: mpu.c mpu.h
  group sam/drivers/matrix
    ../../../../drivers/matrix/: matrix.c matrix.h
  group sam/applications/getting-started
    ../../: main.c
  group sam/applications/getting-started/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_board.h conf_clock.h
  group sam/applications/getting-started/same70q21_same70_xplained/iar
    ./: asf.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../utils/cmsis/same70/include/: same70q21b.h same70j19b.h same70q20.h same70n20.h same70q20b.h same70n19b.h same70j21b.h same70j20.h same70q19b.h same70j21.h same70n21.h same70n20b.h same70q21.h same70q19.h same70n19.h same70j19.h same70.h same70n21b.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../utils/cmsis/same70/include/instance/: pioc.h afec1.h trng.h icm.h isi.h mcan0.h ssc.h matrix.h spi1.h pioe.h twihs2.h pmc.h twihs0.h acc.h hsmci.h uart0.h pioa.h uart2.h piob.h mcan1.h sdramc.h pwm1.h spi0.h piod.h gpbr.h usart2.h rswdt.h twihs1.h tc0.h dacc.h tc2.h smc.h pwm0.h rtt.h i2sc0.h tc1.h uart4.h efc.h tc3.h usart0.h supc.h afec0.h xdmac.h utmi.h i2sc1.h rtc.h wdt.h aes.h uart1.h chipid.h usbhs.h gmac.h uart3.h qspi.h usart1.h rstc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../utils/cmsis/same70/include/component/: matrix.h sdramc.h afec.h gmac.h uart.h mcan.h aes.h usart.h twihs.h pwm.h qspi.h pio.h rtt.h usbhs.h wdt.h tc.h rstc.h spi.h icm.h chipid.h rtc.h supc.h smc.h rswdt.h xdmac.h acc.h ssc.h efc.h trng.h utmi.h i2sc.h isi.h hsmci.h dacc.h pmc.h gpbr.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../utils/cmsis/same70/include/pio/: same70q21b.h same70n19b.h same70q20b.h same70q19b.h same70j19b.h same70n21.h same70q19.h same70n20.h same70q20.h same70n19.h same70n21b.h same70n20b.h same70j20b.h same70j20.h same70q21.h same70j21.h same70j21b.h same70j19.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/boards/same70_xplained
    ../../../../boards/same70_xplained/: init.c led.h same70_xplained.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/same70
    ../../../../../common/services/clock/same70/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
