# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../common/services/clock; ../../../../../../../sam/utils/cmsis/samg/samg53/source/templates; ../../../../../../../sam/utils; ../../../../../../../sam/utils/cmsis/samg/samg53/include; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/boards/samg53_xplained_pro; ../../../../../../../sam/utils/fpu; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ..; ../../../../../../../sam/drivers/supc; ../../../../../../../common/utils; ../../../Common/Include; ../../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Source
    ../../../Common/Source/: math_helper.c
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Include
    ../../../Common/Include/: math_helper.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c documentation.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/samg53n19_samg_xplained_pro
    ../: conf_board.h conf_clock.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../../../sam/utils/cmsis/samg/samg53/source/templates/: system_samg53.c exceptions.c exceptions.h system_samg53.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/: samg53.h samg53n19.h samg53g19.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/component/: component_adc.h component_spi.h component_usart.h component_pio.h component_pdc.h component_pmc.h component_gpbr.h component_wdt.h component_matrix.h component_rtc.h component_tc.h component_rstc.h component_efc.h component_uart.h component_chipid.h component_pdmic.h component_supc.h component_twihs.h component_twi.h component_rtt.h component_mem2mem.h component_i2sc.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/instance/: instance_twi1.h instance_gpbr.h instance_pdmic0.h instance_spi.h instance_rtc.h instance_i2sc0.h instance_efc.h instance_pioa.h instance_matrix.h instance_tc1.h instance_mem2mem.h instance_chipid.h instance_tc0.h instance_rtt.h instance_twi2.h instance_adc.h instance_twi0.h instance_pdmic1.h instance_usart.h instance_supc.h instance_i2sc1.h instance_piob.h instance_uart1.h instance_wdt.h instance_uart0.h instance_pmc.h instance_rstc.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../../../sam/utils/cmsis/samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/boards/samg53_xplained_pro
    ../../../../../../../sam/boards/samg53_xplained_pro/: board_init.c led.h samg53_xplained_pro.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samg
    ../../../../../../../common/services/clock/samg/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
