# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils; ../../../../../../../sam/boards/same70_xplained; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/fpu; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../common/services/clock; ../../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../../sam/drivers/pio; ../../../../../../../common/utils; ../../../../../../../sam/drivers/mpu; ../../../../../../../common/services/gpio; ..; ../../../../../../../common/services/ioport; ../../../../../../../sam/utils/cmsis/same70/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../sam/utils/cmsis/same70/include/: same70q20b.h same70j19.h same70q20.h same70n20.h same70j20.h same70j21b.h same70j21.h same70q21.h same70q21b.h same70n19.h same70q19b.h same70j19b.h same70n20b.h same70n21b.h same70n19b.h same70q19.h same70n21.h same70.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../sam/utils/cmsis/same70/include/instance/: rstc.h trng.h usbhs.h rswdt.h smc.h isi.h afec0.h icm.h gpbr.h qspi.h spi1.h uart4.h mcan0.h tc3.h rtt.h tc1.h aes.h dacc.h chipid.h hsmci.h efc.h sdramc.h uart1.h i2sc1.h pioc.h piod.h matrix.h tc2.h uart3.h usart1.h uart2.h pioe.h usart2.h supc.h acc.h twihs0.h pwm0.h i2sc0.h rtc.h xdmac.h usart0.h pioa.h spi0.h wdt.h pmc.h utmi.h tc0.h twihs1.h gmac.h afec1.h twihs2.h piob.h pwm1.h uart0.h mcan1.h ssc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../sam/utils/cmsis/same70/include/component/: matrix.h qspi.h twihs.h rstc.h pmc.h tc.h i2sc.h chipid.h dacc.h pwm.h rtt.h aes.h ssc.h uart.h smc.h rswdt.h acc.h efc.h wdt.h afec.h isi.h gmac.h usbhs.h mcan.h sdramc.h xdmac.h utmi.h icm.h usart.h spi.h hsmci.h gpbr.h pio.h rtc.h trng.h supc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70q19b.h same70n19b.h same70q21b.h same70q19.h same70j20b.h same70q20.h same70n21b.h same70n20.h same70j19b.h same70j20.h same70n21.h same70j21.h same70j21b.h same70n20b.h same70n19.h same70j19.h same70q21.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h stringz.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c math_helper.c documentation.h math_helper.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/same70q21_same70_xplained
    ../: conf_clock.h conf_board.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/same70q21_same70_xplained/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/same70
    ../../../../../../../common/services/clock/same70/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
