# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../common/services/gpio; ..; ../../../../../../../sam/boards/atpl230amb; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/supc; ../../../../../../../common/utils; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../Common/Include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Source
    ../../../Common/Source/: math_helper.c
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Include
    ../../../Common/Include/: math_helper.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c documentation.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4sd32c_atpl230amb
    ../: conf_clock.h conf_board.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4sd32c_atpl230amb/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group sam/boards/atpl230amb
    ../../../../../../../sam/boards/atpl230amb/: init.c atpl230amb.h led.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s16c.h sam4sd32c.h sam4s2b.h sam4s4b.h sam4sd32b.h system_sam4s.h sam4sd16b.h sam4s16b.h sam4sa16c.h sam4s8b.h sam4sd16c.h sam4s.h sam4s8c.h sam4sa16b.h sam4s4c.h sam4s2a.h sam4s4a.h sam4s2c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_adc.h instance_piob.h instance_udp.h instance_matrix.h instance_ssc.h instance_chipid.h instance_usart0.h instance_acc.h instance_rstc.h instance_hsmci.h instance_twi0.h instance_efc1.h instance_rtt.h instance_usart1.h instance_supc.h instance_tc0.h instance_uart0.h instance_uart1.h instance_gpbr.h instance_smc.h instance_efc0.h instance_pioa.h instance_rtc.h instance_pioc.h instance_tc1.h instance_cmcc.h instance_pmc.h instance_dacc.h instance_pwm.h instance_wdt.h instance_spi.h instance_crccu.h instance_twi1.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_twi.h component_acc.h component_pio.h component_spi.h component_hsmci.h component_rstc.h component_usart.h component_chipid.h component_adc.h component_smc.h component_wdt.h component_udp.h component_pwm.h component_dacc.h component_cmcc.h component_matrix.h component_efc.h component_gpbr.h component_ssc.h component_pmc.h component_supc.h component_rtt.h component_crccu.h component_rtc.h component_uart.h component_pdc.h component_tc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s4b.h pio_sam4sd16c.h pio_sam4s8b.h pio_sam4sd16b.h pio_sam4sd32b.h pio_sam4s2c.h pio_sam4sa16b.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4sd32c.h pio_sam4s2a.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s8c.h pio_sam4s16c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
