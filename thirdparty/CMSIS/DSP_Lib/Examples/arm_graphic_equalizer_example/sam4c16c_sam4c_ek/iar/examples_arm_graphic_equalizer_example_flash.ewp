# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/cmsis/sam4c/include; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/sam4c/source/templates; ../../../../../../../common/services/clock; ../../../../../../../common/services/ioport; ..; ../../../../../../../sam/boards/sam4c_ek; ../../../../../../../sam/drivers/pmc; ../../../../../../../common/utils; ../../../Common/Include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Source
    ../../../Common/Source/: math_helper.c
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Include
    ../../../Common/Include/: math_helper.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c documentation.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4c16c_sam4c_ek
    ../: conf_board.h conf_clock.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../../sam/utils/cmsis/sam4c/include/: sam4c32c_0.h sam4c8c_0.h sam4c32e_1.h sam4c16c_0.h sam4c.h sam4c32c_1.h sam4c16c_1.h sam4c32e_0.h system_sam4c.h sam4c8c_1.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_uotghs.h instance_tc1.h instance_rtt.h instance_pmc.h instance_cmcc1.h instance_usart0.h instance_adc.h instance_ipc0.h instance_usart2.h instance_pwm.h instance_spi0.h instance_rtc.h instance_aes.h instance_wdt.h instance_cmcc0.h instance_chipid.h instance_usart1.h instance_slcdc.h instance_usart3.h instance_trng.h instance_smc1.h instance_uart1.h instance_matrix0.h instance_rswdt.h instance_gpbr.h instance_twi1.h instance_smc0.h instance_efc1.h instance_icm.h instance_efc.h instance_matrix1.h instance_supc.h instance_piob.h instance_tc0.h instance_pioa.h instance_uart0.h instance_piod.h instance_pioc.h instance_usart4.h instance_twi0.h instance_ipc1.h instance_efc0.h instance_rstc.h instance_spi1.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c32c.h pio_sam4c8c.h pio_sam4c32e.h pio_sam4c16c.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../../sam/utils/cmsis/sam4c/include/component/: component_trng.h component_wdt.h component_slcdc.h component_aes.h component_chipid.h component_gpbr.h component_cmcc.h component_efc.h component_rtt.h component_rstc.h component_rswdt.h component_uotghs.h component_tc.h component_pmc.h component_uart.h component_pio.h component_rtc.h component_adc.h component_twi.h component_smc.h component_matrix.h component_pdc.h component_supc.h component_spi.h component_usart.h component_pwm.h component_icm.h component_ipc.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/boards/sam4c_ek
    ../../../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4c
    ../../../../../../../common/services/clock/sam4c/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
