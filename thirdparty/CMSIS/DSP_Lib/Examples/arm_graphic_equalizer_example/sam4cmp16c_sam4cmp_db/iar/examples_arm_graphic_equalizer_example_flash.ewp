# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMP16C_0 Atmel ATSAM4CMP16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../../sam/utils; ..; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../../../common/utils; ../../../Common/Include; ../../../../../../../sam/boards/sam4cmp_db; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cmp16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms16c_0.h sam4cms8c_1.h system_sam4cm.h sam4cms16c_1.h sam4cmp16c_1.h sam4cm.h sam4cmp16c_0.h sam4cms8c_0.h sam4cmp8c_1.h sam4cmp8c_0.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../sam/utils/cmsis/sam4cm/include/component/: slcdc.h adc.h spi.h pmc.h wdt.h uart.h matrix.h pdc.h rtc.h chipid.h twi.h gpbr.h ipc.h usart.h pio.h efc.h smc.h rstc.h trng.h rtt.h rswdt.h pwm.h icm.h supc.h aes.h cmcc.h tc.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: twi1.h usart3.h cmcc0.h ipc0.h tc1.h rtc.h spi1.h wdt.h supc.h matrix1.h usart1.h pmc.h cmcc1.h spi0.h ipc1.h tc0.h rtt.h usart2.h uart0.h slcdc.h aes.h trng.h smc0.h rstc.h adc.h icm.h uart1.h matrix0.h usart0.h piob.h efc.h chipid.h twi0.h smc1.h pioa.h gpbr.h pwm.h rswdt.h pioc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cms16c.h sam4cmp8c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/boards/sam4cmp_db
    ../../../../../../../sam/boards/sam4cmp_db/: init.c sam4cmp_db.h led.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Source
    ../../../Common/Source/: math_helper.c
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Include
    ../../../Common/Include/: math_helper.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c documentation.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4cmp16c_sam4cmp_db
    ../: conf_clock.h conf_board.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4cmp16c_sam4cmp_db/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4cm
    ../../../../../../../common/services/clock/sam4cm/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
