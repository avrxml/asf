# IAR project bench_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../..; ../../../../../../common/services/serial; ../../../../../../avr32/drivers/gpio; ../../../../../../common/services/clock; ../../../../../../common/services/serial/uc3_usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards/evk1104; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../../../../../common/utils; ../../../../include; ../../../../../../avr32/drivers/intc; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/polarssl
    ../../../../: x509parse.c base64.c timing.c xtea.c md2.c arc4.c sha1.c ssl_cli.c certs.c ssl_srv.c padlock.c camellia.c bignum.c sha2.c havege.c dhm.c debug.c rsa.c des.c aes.c sha4.c md5.c md4.c
  group thirdparty/polarssl/examples/bench_example
    ../../: benchmark.c documentation.h
  group thirdparty/polarssl/examples/bench_example/at32uc3a3256_evk1104
    ../: conf_stdio_serial.h conf_clock.h conf_board.h conf_usart_serial.h
  group thirdparty/polarssl/examples/bench_example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group thirdparty/polarssl/include/polarssl
    ../../../../include/polarssl/: md2.h rsa.h net.h debug.h bn_mul.h timing.h arc4.h base64.h x509.h md5.h md4.h ssl.h xtea.h certs.h padlock.h sha2.h sha4.h sha1.h aes.h bignum.h havege.h dhm.h camellia.h config.h openssl.h des.h
  group thirdparty/polarssl/docsrc
    ../../../../docsrc/: documentation.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../common/services/clock/uc3a3_a4/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group avr32/boards/evk1104
    ../../../../../../avr32/boards/evk1104/: init.c led.c evk1104.h led.h
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
