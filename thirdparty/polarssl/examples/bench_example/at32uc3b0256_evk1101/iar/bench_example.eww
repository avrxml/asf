<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bench_example.ewp</path>
	</project>
</workspace>
