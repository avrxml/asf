# IAR project png_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1FFFFFF
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../avr32/drivers/scif; ../../../../../avr32/drivers/ebi/sdramc; ../../../../../avr32/boards; ../../../../../avr32/drivers/pm; ../../../../../avr32/components/display/et024006dhu; ../../../../../avr32/boards/uc3c_ek; ../../../../../avr32/utils/debug; ../../../../../avr32/utils; ../../..; ../../../../../avr32/drivers/gpio; ../../../../../common/utils; ../../../../../avr32/components/memory/sdram; ../../../../../common/services/clock; ../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../common/services/delay; ../../../../../avr32/drivers/ebi/smc; ../../../../../common/boards; ../../../../../avr32/drivers/usart; ../../../../../avr32/drivers/flashc; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/drivers/intc; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3c0512c_extsdram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/uc3c
    ../../../../../common/services/clock/uc3c/: osc.c pll.c sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/lodepng
    ../../../: lodepng.c lodepng.h
  group thirdparty/lodepng/example
    ../../: lodepng_example.c conf_clock.h thor1.h conf_ebi.h conf_et024006dhu.h pngfile.h
  group thirdparty/lodepng/example/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group avr32/drivers/ebi/sdramc
    ../../../../../avr32/drivers/ebi/sdramc/: sdramc.c sdramc.h
  group avr32/drivers/ebi/smc
    ../../../../../avr32/drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/intc
    ../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c pm_uc3c.h power_clocks_lib.h sleep.h
  group avr32/drivers/usart
    ../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/scif
    ../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../avr32/utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../avr32/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group avr32/utils/header_files
    ../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/uc3c_ek
    ../../../../../avr32/boards/uc3c_ek/: led.c uc3c_ek.h led.h
  group avr32/components/display/et024006dhu
    ../../../../../avr32/components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e
    ../../../../../avr32/components/memory/sdram/mt48lc16m16a2tg7e/: mt48lc16m16a2tg7e.h
