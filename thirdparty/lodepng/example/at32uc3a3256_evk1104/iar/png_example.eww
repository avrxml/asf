<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\png_example.ewp</path>
	</project>
</workspace>
