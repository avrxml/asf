<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ijg_example.ewp</path>
	</project>
</workspace>
