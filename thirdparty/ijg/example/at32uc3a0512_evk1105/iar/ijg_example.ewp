# IAR project ijg_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1FFFFFF
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../avr32/drivers/ebi/sdramc; ../../../../../avr32/boards; ../../../../../avr32/drivers/pm; ../../../../../avr32/components/display/et024006dhu; ../../../../../avr32/utils/debug; ../../../../../avr32/boards/evk1105; ../../../../../avr32/utils; ../../../../../avr32/drivers/gpio; ../../../../../common/utils; ../../../../../avr32/components/memory/sdram; ../../..; ../../../../../common/services/clock; ../../../../../avr32/drivers/pwm; ../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../common/services/delay; ../../../../../avr32/drivers/ebi/smc; ../../../../../common/boards; ../../../../../avr32/drivers/usart; ../../../../../avr32/drivers/flashc; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3a0512_extsdram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/ijg
    ../../../: jdmarker.c jquant2.c jccoefct.c jdpostct.c jdphuff.c jerror.c jddctmgr.c jfdctfst.c jcparam.c jcphuff.c jcmainct.c jcsample.c jdsample.c jcomapi.c jdmainct.c jcinit.c jidctint.c jfdctint.c jidctflt.c jdapimin.c jdapistd.c jchuff.c jidctfst.c jdtrans.c jquant1.c jdmerge.c jcdctmgr.c jidctred.c jdhuff.c jdmaster.c jmemnobs.c jcprepct.c jctrans.c jfdctflt.c jmemmgr.c jccolor.c jcmaster.c jdcolor.c jutils.c jdcoefct.c jcapistd.c jdinput.c jcmarker.c jinclude.h transupp.h jerror.h jdct.h cdjpeg.h jchuff.h jpeglib.h jmorecfg.h jconfig.h cderror.h jdhuff.h jversion.h jmemsys.h jpegint.h
  group thirdparty/ijg/example
    ../../: jdatasrc.c ijg_example.c conf_clock.h jpegfile.h conf_ebi.h jpeg_decoder.h conf_jpeg_decoder.h conf_et024006dhu.h
  group thirdparty/ijg/example/at32uc3a0512_evk1105/iar
    ./: asf.h
  group thirdparty/ijg/docsrc
    ../../../docsrc/: documentation.h
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c pm.h sleep.h power_clocks_lib.h
  group avr32/drivers/ebi/sdramc
    ../../../../../avr32/drivers/ebi/sdramc/: sdramc.c sdramc.h
  group avr32/drivers/ebi/smc
    ../../../../../avr32/drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/intc
    ../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/usart
    ../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pwm
    ../../../../../avr32/drivers/pwm/: pwm.c pwm.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1105
    ../../../../../avr32/boards/evk1105/: led.c led.h evk1105.h
  group avr32/utils
    ../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../avr32/utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../avr32/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group avr32/utils/header_files
    ../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/components/display/et024006dhu
    ../../../../../avr32/components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e
    ../../../../../avr32/components/memory/sdram/mt48lc16m16a2tg7e/: mt48lc16m16a2tg7e.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/uc3a0_a1
    ../../../../../common/services/clock/uc3a0_a1/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
