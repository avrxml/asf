<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\thirdparty_lwip_netconn_http_stats_example_flash.ewp</path>
	</project>
</workspace>
