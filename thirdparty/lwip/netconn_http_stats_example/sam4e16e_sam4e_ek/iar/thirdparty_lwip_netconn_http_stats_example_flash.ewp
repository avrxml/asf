# IAR project thirdparty_lwip_netconn_http_stats_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; BOARD=SAM4E_EK; FREERTOS_USED=1; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../sam/utils/header_files; ../../../../../common/services/spi/sam_spi; ../../../lwip-1.4.1/src/include/ipv4; ../../../../../sam/drivers/rstc; ../../../../../sam/utils/preprocessor; ../../../../../sam/components/ethernet_phy/ksz8051mnl; ../../../../../sam/drivers/pio; ../../../../../sam/components/display/ili93xx; ../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f; ../../network/httpserver; ../../../lwip-1.4.1/src/include; ../../../../../sam/drivers/ebi/smc; ../../../../../sam/utils/fpu; ../../../../../common/services/serial; ../../../../../common/services/clock; ../../../../../sam/drivers/spi; ../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../sam/drivers/pdc; ../../../../../common/utils; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam/drivers/gmac; ../../../../../sam/components/resistive_touch/ads7843; ../../../../freertos/freertos-7.3.0/source/include; ../../../../../sam/boards; ../../../../../sam/components/display/aat31xx; ../../../../../common/utils/stdio/stdio_serial; ../../../../../sam/utils/cmsis/sam4e/include; ..; ../../../../../common/services/gpio; ../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../common/services/spi; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../sam/services/resistive_touch; ../../../../../common/services/ioport; ../../../../../sam/drivers/pmc; ../../../lwip-port-1.4.1/sam/include; ../../network; ../../../../../sam/boards/sam4e_ek; ../..; ../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_netconn_http_stats_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_netconn_http_stats_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c netdb.c tcpip.c err.c netifapi.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: mem.c stats.c tcp_in.c dhcp.c lwip_init.c udp.c dns.c sys.c raw.c def.c pbuf.c netif.c tcp_out.c tcp.c lwip_timers_141.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c inet.c ip_addr.c ip.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: def.h snmp_msg.h err.h netdb.h snmp.h netifapi.h sockets.h netif.h api.h dns.h dhcp.h timers.h udp.h mem.h pbuf.h netbuf.h raw.h opt.h debug.h sio.h memp.h arch.h snmp_asn1.h init.h api_msg.h memp_std.h sys.h tcp.h tcpip.h snmp_structs.h stats.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h inet.h ip.h igmp.h autoip.h ip_addr.h icmp.h inet_chksum.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/netconn_http_stats_example
    ../../: main.c task_gfx.c task_http.c FreeRTOSConfig.h task_defs.h logo_atmel.h
  group thirdparty/lwip/netconn_http_stats_example/network
    ../../network/: ethernet.c ethernet.h
  group thirdparty/lwip/netconn_http_stats_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c cgi.c fs.c fsdata.h index.h atmel.h jquery.h jqflot.h style.h favicon.h httpd.h excan.h cgi.h fs.h
  group thirdparty/lwip/netconn_http_stats_example/sam4e16e_sam4e_ek
    ../: lwipopts.h conf_uart_serial.h conf_clock.h conf_board.h conf_eth.h conf_spi_master.h conf_ili93xx.h conf_ads7843.h conf_aat31xx.h
  group thirdparty/lwip/netconn_http_stats_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam
    ../../../lwip-port-1.4.1/sam/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: sam4e_gmac.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: sam4e_gmac.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: sys_arch.h perf.h cc.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos/freertos-7.3.0/source/: FreeRTOS_CLI.c tasks.c queue.c list.c timers.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../freertos/freertos-7.3.0/source/include/: FreeRTOS_CLI.h projdefs.h mpu_wrappers.h StackMacros.h croutine.h queue.h list.h FreeRTOS.h portable.h timers.h task.h semphr.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/rstc
    ../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../../sam/drivers/rstc/example1/: rstc_example1.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/gmac
    ../../../../../sam/drivers/gmac/: gmac_phy.c gmac.h
  group sam/drivers/ebi/smc
    ../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/pdc
    ../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/services/resistive_touch
    ../../../../../sam/services/resistive_touch/: rtouch.c rtouch_ads7843.h rtouch.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../sam/utils/cmsis/sam4e/include/: sam4e16c.h sam4e.h sam4e8c.h sam4e16e.h sam4e8e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../sam/utils/cmsis/sam4e/include/component/: gmac.h acc.h pio.h usart.h afec.h dmac.h uart.h chipid.h rtt.h pwm.h pdc.h gpbr.h udp.h smc.h pmc.h aes.h rtc.h hsmci.h supc.h twi.h matrix.h spi.h cmcc.h efc.h dacc.h rstc.h can.h rswdt.h wdt.h tc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../sam/utils/cmsis/sam4e/include/instance/: rtt.h twi1.h dmac.h cmcc.h piob.h pmc.h acc.h rtc.h rswdt.h piod.h twi0.h smc.h pwm.h uart1.h gpbr.h afec0.h can1.h matrix.h chipid.h usart0.h hsmci.h pioc.h efc.h uart0.h afec1.h dacc.h tc0.h wdt.h can0.h supc.h gmac.h spi.h usart1.h tc2.h udp.h rstc.h pioa.h tc1.h aes.h pioe.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e8c.h sam4e16c.h sam4e16e.h sam4e8e.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/components/display/ili93xx
    ../../../../../sam/components/display/ili93xx/: ili93xx.c ili9325_regs.h ili9341_regs.h ili93xx.h
  group sam/components/display/aat31xx
    ../../../../../sam/components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../../sam/components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/components/resistive_touch/ads7843
    ../../../../../sam/components/resistive_touch/ads7843/: ads7843.c ads7843.h
  group sam/boards/sam4e_ek
    ../../../../../sam/boards/sam4e_ek/: init.c led.h sam4e_ek.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
