# IAR project thirdparty_lwip_raw_basic_http_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../..; ../../network/httpserver; ../../../../../sam/utils/header_files; ../../../lwip-1.4.1/src/include/ipv4; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../../../sam/boards/sam3x_ek; ../../network; ../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../lwip-1.4.1/src/include; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../common/services/serial; ../../../../../sam/utils/cmsis/sam3x/include; ../../../../../common/utils; ../../../../../sam/drivers/rstc; ../../../../../sam/drivers/emac; ..; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../sam/components/ethernet_phy/dm9161a; ../../../../../common/services/ioport; ../../../../../sam/drivers/pio; ../../../lwip-port-1.4.1/sam/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c tcpip.c err.c netdb.c netifapi.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c tcp_out.c dns.c netif.c sys.c pbuf.c raw.c def.c memp.c udp.c tcp.c lwip_timers_141.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c inet.c ip_addr.c ip.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: def.h timers.h snmp_msg.h err.h netdb.h snmp.h netbuf.h sockets.h netif.h opt.h api.h dns.h dhcp.h udp.h pbuf.h raw.h netifapi.h debug.h sio.h memp.h mem.h arch.h init.h snmp_asn1.h api_msg.h memp_std.h sys.h tcp.h tcpip.h snmp_structs.h stats.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h icmp.h inet.h ip.h igmp.h ip_addr.h autoip.h inet_chksum.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example
    ../../: raw_http_basic_example.c
  group thirdparty/lwip/raw_http_basic_example/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h lwipopts.h conf_eth.h
  group thirdparty/lwip/raw_http_basic_example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: ethernetif.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: ethernetif.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/rstc
    ../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../../sam/drivers/rstc/example1/: rstc_example1.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/emac
    ../../../../../sam/drivers/emac/: emac.c emac.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/dm9161a
    ../../../../../sam/components/ethernet_phy/dm9161a/: ethernet_phy.c ethernet_phy.h mii.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../sam/utils/cmsis/sam3x/include/: sam3x4e.h sam3x8h.h sam3x4c.h sam3a8c.h sam3x8c.h sam3a4c.h sam3x8e.h sam3xa.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../sam/utils/cmsis/sam3x/include/component/: component_twi.h component_emac.h component_ssc.h component_matrix.h component_rstc.h component_uotghs.h component_efc.h component_usart.h component_rtc.h component_hsmci.h component_uart.h component_dacc.h component_chipid.h component_trng.h component_dmac.h component_smc.h component_sdramc.h component_rtt.h component_pdc.h component_pio.h component_gpbr.h component_can.h component_supc.h component_tc.h component_spi.h component_pwm.h component_wdt.h component_pmc.h component_adc.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3x4e.h pio_sam3x8e.h pio_sam3a8c.h pio_sam3x8h.h pio_sam3x4c.h pio_sam3x8c.h pio_sam3a4c.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_pwm.h instance_rtc.h instance_supc.h instance_efc0.h instance_piob.h instance_pioa.h instance_piod.h instance_pioc.h instance_piof.h instance_dacc.h instance_twi1.h instance_usart0.h instance_efc1.h instance_usart2.h instance_spi0.h instance_tc0.h instance_emac.h instance_trng.h instance_matrix.h instance_pmc.h instance_usart1.h instance_adc.h instance_twi0.h instance_usart3.h instance_dmac.h instance_sdramc.h instance_tc1.h instance_gpbr.h instance_hsmci.h instance_can1.h instance_wdt.h instance_tc2.h instance_ssc.h instance_chipid.h instance_uart.h instance_smc.h instance_can0.h instance_uotghs.h instance_rstc.h instance_pioe.h instance_spi1.h instance_rtt.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3x_ek
    ../../../../../sam/boards/sam3x_ek/: init.c led.c led.h sam3x_ek.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h genclk.h pll.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
