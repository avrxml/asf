# IAR project thirdparty_lwip_raw_basic_http_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../..; ../../network/httpserver; ../../../../../sam/utils/header_files; ../../../lwip-1.4.1/src/include/ipv4; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam/utils/preprocessor; ../../../../../sam/components/ethernet_phy/ksz8051mnl; ../../../../../sam/drivers/pmc; ../../network; ../../../lwip-1.4.1/src/include; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../sam/utils/fpu; ../../../../../common/services/serial; ../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../common/utils; ../../../../../sam/drivers/gmac; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../sam/utils/cmsis/sam4e/include; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../lwip-port-1.4.1/sam/include; ../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c netdb.c tcpip.c err.c netifapi.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c dns.c sys.c pbuf.c raw.c def.c netif.c udp.c tcp_out.c tcp.c lwip_timers_141.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c inet.c ip_addr.c ip.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: stats.h def.h snmp_msg.h err.h netdb.h snmp.h netifapi.h sockets.h netif.h api.h dns.h sio.h udp.h mem.h pbuf.h netbuf.h raw.h opt.h debug.h memp.h arch.h snmp_asn1.h init.h api_msg.h snmp_structs.h sys.h tcp.h dhcp.h tcpip.h memp_std.h timers.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h inet.h ip.h igmp.h autoip.h ip_addr.h icmp.h inet_chksum.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example
    ../../: raw_http_basic_example.c
  group thirdparty/lwip/raw_http_basic_example/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_eth.h lwipopts.h
  group thirdparty/lwip/raw_http_basic_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: sam4e_gmac.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: sam4e_gmac.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/gmac
    ../../../../../sam/drivers/gmac/: gmac_phy.c gmac.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../sam/utils/cmsis/sam4e/include/: sam4e16c.h sam4e.h sam4e8e.h sam4e8c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../sam/utils/cmsis/sam4e/include/component/: gmac.h acc.h pio.h usart.h afec.h dmac.h uart.h chipid.h rtt.h pwm.h pdc.h gpbr.h smc.h udp.h pmc.h aes.h rtc.h hsmci.h supc.h twi.h matrix.h spi.h cmcc.h efc.h dacc.h rstc.h can.h rswdt.h wdt.h tc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../sam/utils/cmsis/sam4e/include/instance/: piob.h rtt.h twi1.h dmac.h cmcc.h usart0.h pmc.h hsmci.h acc.h rtc.h piod.h spi.h twi0.h smc.h pwm.h uart1.h gpbr.h afec0.h can1.h matrix.h chipid.h pioc.h efc.h uart0.h afec1.h dacc.h tc0.h wdt.h can0.h supc.h gmac.h usart1.h tc2.h udp.h rstc.h pioa.h rswdt.h tc1.h aes.h pioe.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e8c.h sam4e16c.h sam4e16e.h sam4e8e.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../../sam/components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/boards/sam4e_ek
    ../../../../../sam/boards/sam4e_ek/: init.c led.h sam4e_ek.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
