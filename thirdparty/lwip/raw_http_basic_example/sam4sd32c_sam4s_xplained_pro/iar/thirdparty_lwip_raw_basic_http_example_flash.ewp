# IAR project thirdparty_lwip_raw_basic_http_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../..; ../../network/httpserver; ../../../../../sam/utils/header_files; ../../../../../common/services/spi/sam_spi; ../../../lwip-1.4.1/src/include/ipv4; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../../../sam/utils/cmsis/sam4s/include; ../../network; ../../../lwip-1.4.1/src/include; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../common/services/serial; ../../../../../sam/components/ethernet_phy/ksz8851snl; ../../../../../sam/drivers/spi; ../../../../../sam/drivers/pdc; ../../../../../common/utils; ../../../../../sam/drivers/wdt; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../common/services/gpio; ../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../common/services/delay; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../../sam/drivers/pio; ../../../lwip-port-1.4.1/sam/include; ..; ../../../../../sam/boards/sam4s_xplained_pro; ../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c netdb.c tcpip.c err.c netifapi.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c dns.c sys.c lwip_timers_141.c pbuf.c raw.c def.c netif.c udp.c tcp_out.c tcp.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c igmp.c ip_frag.c autoip.c icmp.c ip_addr.c ip.c inet.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: stats.h def.h snmp_msg.h err.h netdb.h snmp.h netifapi.h netbuf.h sockets.h netif.h api.h timers.h dhcp.h sio.h udp.h mem.h tcpip.h pbuf.h raw.h opt.h debug.h memp.h arch.h snmp_asn1.h init.h api_msg.h snmp_structs.h sys.h dns.h tcp.h memp_std.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h inet.h ip.h igmp.h autoip.h ip_addr.h icmp.h inet_chksum.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example
    ../../: raw_http_basic_example.c
  group thirdparty/lwip/raw_http_basic_example/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example/sam4sd32c_sam4s_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_eth.h lwipopts.h conf_spi_master.h conf_clock.h
  group thirdparty/lwip/raw_http_basic_example/sam4sd32c_sam4s_xplained_pro/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: sam_spi_ksz8851snl.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: cc.h perf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: sam_spi_ksz8851snl.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/boards/sam4s_xplained_pro
    ../../../../../sam/boards/sam4s_xplained_pro/: init.c sam4s_xplained_pro.h led.h
  group sam/drivers/wdt
    ../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pdc
    ../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../sam/utils/cmsis/sam4s/include/: sam4s2b.h sam4s2a.h sam4s8b.h sam4sa16c.h sam4s16b.h sam4sa16b.h sam4sd32b.h sam4s4c.h sam4s16c.h sam4sd32c.h sam4s2c.h sam4s.h sam4s4a.h sam4sd16b.h sam4s4b.h sam4s8c.h sam4sd16c.h system_sam4s.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../sam/utils/cmsis/sam4s/include/component/: component_adc.h component_cmcc.h component_ssc.h component_matrix.h component_efc.h component_pio.h component_twi.h component_rtc.h component_pmc.h component_acc.h component_uart.h component_wdt.h component_rstc.h component_supc.h component_spi.h component_dacc.h component_pdc.h component_tc.h component_pwm.h component_usart.h component_hsmci.h component_smc.h component_chipid.h component_crccu.h component_rtt.h component_gpbr.h component_udp.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_rtc.h instance_crccu.h instance_piob.h instance_twi0.h instance_usart0.h instance_wdt.h instance_pwm.h instance_usart1.h instance_dacc.h instance_chipid.h instance_udp.h instance_adc.h instance_tc1.h instance_uart0.h instance_rstc.h instance_uart1.h instance_acc.h instance_tc0.h instance_ssc.h instance_smc.h instance_hsmci.h instance_efc0.h instance_rtt.h instance_efc1.h instance_gpbr.h instance_spi.h instance_supc.h instance_pioc.h instance_pioa.h instance_twi1.h instance_pmc.h instance_matrix.h instance_cmcc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s2b.h pio_sam4s4c.h pio_sam4sd32c.h pio_sam4sd32b.h pio_sam4s16c.h pio_sam4sd16b.h pio_sam4s2c.h pio_sam4s4b.h pio_sam4s8c.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4sa16c.h pio_sam4s8b.h pio_sam4s4a.h pio_sam4s2a.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/components/ethernet_phy/ksz8851snl
    ../../../../../sam/components/ethernet_phy/ksz8851snl/: ksz8851snl.c ksz8851snl_reg.h ksz8851snl.h
