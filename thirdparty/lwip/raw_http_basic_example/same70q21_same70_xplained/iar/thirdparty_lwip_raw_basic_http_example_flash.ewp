# IAR project thirdparty_lwip_raw_basic_http_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../..; ../../network/httpserver; ../../../../../sam/utils/header_files; ../../../lwip-1.4.1/src/include/ipv4; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam/utils/preprocessor; ../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../sam/drivers/pmc; ../../network; ../../../../../sam/utils/cmsis/same70/include; ../../../lwip-1.4.1/src/include; ../../../../../sam/components/ethernet_phy/ksz8081rna; ../../../lwip-port-1.4.1/sam/include/netif; ..; ../../../../../common/services/serial; ../../../../../sam/drivers/mpu; ../../../../../common/utils; ../../../../../sam/drivers/gmac; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../sam/boards/same70_xplained; ../../../../../common/services/gpio; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../sam/utils/fpu; ../../../../../common/services/ioport; ../../../../../sam/drivers/pio; ../../../lwip-port-1.4.1/sam/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAME70_XPLAINED; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netdb.c api_msg.c tcpip.c err.c netifapi.c netbuf.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c lwip_timers_141.c lwip_init.c tcp_out.c dns.c sys.c pbuf.c raw.c def.c netif.c udp.c dhcp.c tcp.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c ip_addr.c ip.c inet.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: stats.h def.h snmp_msg.h netdb.h snmp.h netifapi.h netbuf.h sockets.h api.h dns.h timers.h sio.h udp.h mem.h raw.h opt.h netif.h debug.h pbuf.h memp.h arch.h snmp_asn1.h init.h api_msg.h snmp_structs.h sys.h tcp.h dhcp.h tcpip.h memp_std.h err.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: autoip.h ip_frag.h inet.h ip.h igmp.h ip_addr.h icmp.h inet_chksum.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example
    ../../: raw_http_basic_example.c
  group thirdparty/lwip/raw_http_basic_example/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_board.h lwipopts.h conf_eth.h conf_clock.h
  group thirdparty/lwip/raw_http_basic_example/same70q21_same70_xplained/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: same70_gmac.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: same70_gmac.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/same70
    ../../../../../common/services/clock/same70/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/gmac
    ../../../../../sam/drivers/gmac/: gmac_phy.c gmac.h
  group sam/drivers/mpu
    ../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../sam/utils/cmsis/same70/include/: same70n21b.h same70n21.h same70j19b.h same70j20b.h same70n19.h same70j21.h same70q19b.h same70j20.h same70q20.h same70q20b.h same70j19.h same70j21b.h same70n20.h same70n19b.h same70.h same70q21.h same70q21b.h same70q19.h same70n20b.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../sam/utils/cmsis/same70/include/pio/: same70q21b.h same70j21b.h same70j19b.h same70q19b.h same70j21.h same70q19.h same70j20.h same70n20.h same70j19.h same70n19.h same70n20b.h same70q21.h same70q20b.h same70q20.h same70n21b.h same70j20b.h same70n19b.h same70n21.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../sam/utils/cmsis/same70/include/component/: supc.h pio.h twihs.h hsmci.h afec.h xdmac.h isi.h trng.h rswdt.h usbhs.h rstc.h i2sc.h gmac.h gpbr.h pwm.h rtc.h dacc.h utmi.h icm.h qspi.h pmc.h wdt.h efc.h rtt.h aes.h spi.h uart.h mcan.h matrix.h smc.h ssc.h usart.h chipid.h tc.h acc.h sdramc.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../sam/utils/cmsis/same70/include/instance/: hsmci.h tc1.h twihs1.h aes.h efc.h spi0.h i2sc1.h rswdt.h qspi.h uart4.h xdmac.h pmc.h tc3.h gpbr.h sdramc.h utmi.h uart0.h trng.h spi1.h icm.h uart3.h usart1.h matrix.h piod.h rtt.h dacc.h tc0.h acc.h ssc.h piob.h usart0.h pwm0.h afec1.h i2sc0.h tc2.h uart1.h mcan1.h smc.h chipid.h twihs2.h pioe.h isi.h usart2.h rtc.h wdt.h mcan0.h pioc.h pwm1.h afec0.h usbhs.h uart2.h supc.h rstc.h twihs0.h gmac.h pioa.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8081rna
    ../../../../../sam/components/ethernet_phy/ksz8081rna/: ethernet_phy.c ethernet_phy.h
  group sam/boards/same70_xplained
    ../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
