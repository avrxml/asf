<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\thirdparty_lwip_raw_basic_http_example_ajax_flash.ewp</path>
	</project>
</workspace>
