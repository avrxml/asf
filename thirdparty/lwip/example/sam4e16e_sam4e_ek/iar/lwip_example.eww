<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\lwip_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\lwip_example_sram.ewp</path>
	</project>
</workspace>
