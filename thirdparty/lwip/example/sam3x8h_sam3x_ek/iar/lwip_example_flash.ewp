# IAR project lwip_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../network; ../../../../../sam/drivers/rstc; ../../../../../sam/utils/preprocessor; ../../../../../sam/components/ethernet_phy/dm9161a; ../../../../../sam/drivers/pmc; ../../../../../sam/boards/sam3x_ek; ../../network/httpserver_raw; ../../../../../sam/utils/header_files; ../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../lwip-1.4.0/src/include; ../../../../../common/services/serial; ../../../lwip-port-1.4.0/sam/include/netif; ../../../../../sam/utils/cmsis/sam3x/include; ../..; ../../../../../common/utils; ../../../../../sam/drivers/emac; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../lwip-1.4.0/src/include/lwip; ../../../../../common/services/gpio; ../../../lwip-1.4.0/src/include/ipv4; ../../../../../sam/drivers/uart; ..; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../lwip-port-1.4.0/sam/include; ../../../../../common/services/ioport; ../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lwip_example_flash.bin
  ILINK.IlinkOutputFile: lwip_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/example
    ../../: standalone_lwip_demo_sam.c lwipopts.h
  group thirdparty/lwip/example/network
    ../../network/: ethernet_sam.c timer_mgt_sam.c timer_mgt_sam.h ethernet_sam.h
  group thirdparty/lwip/example/network/httpserver_raw
    ../../network/httpserver_raw/: httpd.c fs.c fsdata.c fsdata.h fs.h httpd.h
  group thirdparty/lwip/example/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_eth.h
  group thirdparty/lwip/example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../lwip-1.4.0/src/core/: raw.c init.c memp.c dhcp.c netif.c tcp.c sys.c tcp_out.c tcp_in.c udp.c pbuf.c dns.c lwip_timers_140.c def.c stats.c mem.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../lwip-1.4.0/src/core/ipv4/: igmp.c ip.c inet.c ip_addr.c inet_chksum.c autoip.c ip_frag.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../lwip-1.4.0/src/api/: tcpip.c netifapi.c api_lib.c api_msg.c sockets.c netbuf.c netdb.c err.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/include/lwip
    ../../../lwip-1.4.0/src/include/lwip/: stats.h snmp_asn1.h sockets.h debug.h tcp.h netif.h memp.h arch.h dns.h err.h netdb.h opt.h dhcp.h api.h mem.h pbuf.h timers.h sys.h tcp_impl.h netifapi.h netbuf.h api_msg.h raw.h snmp_structs.h snmp.h snmp_msg.h memp_std.h tcpip.h sio.h def.h init.h udp.h
  group thirdparty/lwip/lwip-1.4.0/src/include/ipv4/lwip
    ../../../lwip-1.4.0/src/include/ipv4/lwip/: autoip.h ip_addr.h igmp.h inet.h icmp.h ip_frag.h inet_chksum.h ip.h
  group thirdparty/lwip/lwip-1.4.0/src/include/netif
    ../../../lwip-1.4.0/src/include/netif/: ppp_oe.h etharp.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../lwip-port-1.4.0/sam/netif/: ethernetif.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/netif
    ../../../lwip-port-1.4.0/sam/include/netif/: ethernetif.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/arch
    ../../../lwip-port-1.4.0/sam/include/arch/: cc.h perf.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/rstc
    ../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/emac
    ../../../../../sam/drivers/emac/: emac.c emac.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/dm9161a
    ../../../../../sam/components/ethernet_phy/dm9161a/: ethernet_phy.c mii.h ethernet_phy.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../sam/utils/cmsis/sam3x/include/: sam3x4e.h sam3x4c.h sam3a8c.h sam3x8c.h sam3a4c.h sam3xa.h sam3x8e.h sam3x8h.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_gpbr.h instance_uart.h instance_rtc.h instance_supc.h instance_efc0.h instance_piob.h instance_pioa.h instance_piod.h instance_pioc.h instance_piof.h instance_dacc.h instance_twi1.h instance_usart0.h instance_rtt.h instance_efc1.h instance_usart2.h instance_tc2.h instance_spi0.h instance_tc0.h instance_emac.h instance_trng.h instance_matrix.h instance_pmc.h instance_usart1.h instance_adc.h instance_twi0.h instance_usart3.h instance_dmac.h instance_sdramc.h instance_pwm.h instance_spi1.h instance_can1.h instance_wdt.h instance_ssc.h instance_chipid.h instance_rstc.h instance_tc1.h instance_smc.h instance_can0.h instance_uotghs.h instance_hsmci.h instance_pioe.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../sam/utils/cmsis/sam3x/include/component/: component_twi.h component_matrix.h component_rstc.h component_uotghs.h component_pio.h component_rtc.h component_hsmci.h component_uart.h component_dacc.h component_emac.h component_chipid.h component_trng.h component_dmac.h component_smc.h component_sdramc.h component_rtt.h component_ssc.h component_pdc.h component_efc.h component_wdt.h component_gpbr.h component_can.h component_supc.h component_tc.h component_spi.h component_pmc.h component_pwm.h component_adc.h component_usart.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3x4e.h pio_sam3a8c.h pio_sam3x4c.h pio_sam3x8e.h pio_sam3x8h.h pio_sam3x8c.h pio_sam3a4c.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3x_ek
    ../../../../../sam/boards/sam3x_ek/: led.c led.h sam3x_ek.h
