<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dlmalloc_example2.ewp</path>
	</project>
</workspace>
