# IAR project libmad-at32ucr1.ewp, settings and files
configuration size_opt (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: FPM_AVR32; HAVE_CONFIG_H
  ICCAVR32.CCIncludePath2: ..\..\..\; 
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration balanced_opt (AVR32)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  ICCAVR32.CCOptStrategy: 0
configuration speed_opt (AVR32)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  ICCAVR32.CCOptStrategy: 2
  group (top)
    ../../../: bit.c dct32_avr32.s82 decoder.c fixed.c frame.c huffman.c imdct_avr32.s82 layer12.c layer3.c layer3_imdct_s_avr32.s82 stream.c synth.c synth_avr32.s82 timer.c version.c
