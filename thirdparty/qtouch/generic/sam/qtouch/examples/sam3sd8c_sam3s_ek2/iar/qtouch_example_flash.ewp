# IAR project qtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; BOARD=SAM3S_EK2; SNSK1=C; SNSK2=A; _SNS2_SNSK2_SAME_PORT_; __SAM3SD8C__; SNS1=C; QT_DELAY_CYCLES=5; ARM_MATH_CM3=true; _QTOUCH_; QT_NUM_CHANNELS=32; SNS2=A; _DEBUG_INTERFACE_
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../qdebug; ..; ../../../../../include; ../../../../../../../../common/services/serial; ../../../../../../../../common/services/clock; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../common; ../../../../../../../../sam/boards/sam3s_ek2; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qtouch_example_flash.bin
  ILINK.IlinkOutputFile: qtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../lib/iar/: libsam3sd8-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/examples
    ../../: qtouch_example.c
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam3sd8c_sam3s_ek2
    ../: conf_uart_serial.h QDebugSettings.h conf_board.h conf_example.h conf_clock.h
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../common/: BitBangSPI_Master.c touch_qt_config.h BitBangSPI_Master.h
  group thirdparty/qtouch/generic/include
    ../../../../../include/: touch_api.h
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebugTransport.c QDebug.c QDebug.h QDebugTransport.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam3s
    ../../../../../../../../common/services/clock/sam3s/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c system_sam3sd8.h exceptions.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/: sam3s8b.h sam3sd8c.h sam3s8.h sam3s8c.h sam3sd8b.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_chipid.h instance_gpbr.h instance_wdt.h instance_rtt.h instance_tc1.h instance_tc0.h instance_acc.h instance_pmc.h instance_usart0.h instance_hsmci.h instance_uart1.h instance_usart2.h instance_twi1.h instance_supc.h instance_spi.h instance_smc.h instance_uart0.h instance_crccu.h instance_usart1.h instance_ssc.h instance_adc.h instance_twi0.h instance_dacc.h instance_efc.h instance_pioc.h instance_matrix.h instance_udp.h instance_rstc.h instance_rtc.h instance_pwm.h instance_pioa.h instance_piob.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_pio.h component_supc.h component_tc.h component_rstc.h component_chipid.h component_rtc.h component_dacc.h component_matrix.h component_twi.h component_udp.h component_smc.h component_rtt.h component_spi.h component_adc.h component_efc.h component_gpbr.h component_pdc.h component_wdt.h component_usart.h component_crccu.h component_ssc.h component_pwm.h component_uart.h component_acc.h component_pmc.h component_hsmci.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3s8b.h pio_sam3s8c.h pio_sam3sd8b.h pio_sam3sd8c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3s_ek2
    ../../../../../../../../sam/boards/sam3s_ek2/: led.c led.h sam3s_ek2.h
