# IAR project qtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; SNSK1=C; BOARD=SAM3N_EK; __SAM3N4C__; SNS1=C; ARM_MATH_CM3=true; QT_DELAY_CYCLES=3; _QTOUCH_; QT_NUM_CHANNELS=32; _DEBUG_INTERFACE_
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../include; ../../../../../../../../common/services/serial; ../../../../../../qdebug; ../../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../../../../sam/boards/sam3n_ek; ../../../common; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qtouch_example_flash.bin
  ILINK.IlinkOutputFile: qtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../lib/iar/: libsam3n-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../common/: BitBangSPI_Master.c touch_qt_config.h BitBangSPI_Master.h
  group thirdparty/qtouch/generic/sam/qtouch/examples
    ../../: qtouch_example.c
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h QDebugSettings.h conf_board.h conf_example.h conf_clock.h
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group thirdparty/qtouch/generic/include
    ../../../../../include/: touch_api.h
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebugTransport.c QDebug.c QDebug.h QDebugTransport.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h sysclk.h genclk.h
  group common/services/clock/sam3n
    ../../../../../../../../common/services/clock/sam3n/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/sam3n_ek
    ../../../../../../../../sam/boards/sam3n_ek/: led.c sam3n_ek.h led.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c system_sam3n.h exceptions.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../../../sam/utils/cmsis/sam3n/include/: sam3n2a.h sam3n1a.h sam3n2c.h sam3n4b.h sam3n.h sam3n4a.h sam3n4c.h sam3n1b.h sam3n2b.h sam3n1c.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_pmc.h instance_rtt.h instance_spi.h instance_pwm.h instance_uart0.h instance_matrix.h instance_usart1.h instance_gpbr.h instance_piob.h instance_tc1.h instance_chipid.h instance_uart1.h instance_tc0.h instance_usart0.h instance_rstc.h instance_pioa.h instance_efc.h instance_pioc.h instance_twi0.h instance_dacc.h instance_supc.h instance_adc.h instance_rtc.h instance_twi1.h instance_wdt.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../../../sam/utils/cmsis/sam3n/include/component/: component_chipid.h component_rstc.h component_gpbr.h component_twi.h component_adc.h component_matrix.h component_rtc.h component_dacc.h component_pdc.h component_usart.h component_pio.h component_supc.h component_pmc.h component_wdt.h component_uart.h component_rtt.h component_tc.h component_efc.h component_pwm.h component_spi.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n1c.h pio_sam3n4b.h pio_sam3n2b.h pio_sam3n1b.h pio_sam3n1a.h pio_sam3n4c.h pio_sam3n4a.h pio_sam3n2a.h pio_sam3n2c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
