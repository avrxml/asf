# IAR project qtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; _SNS2_SNSK2_SAME_PORT_; BOARD=SAM3X_EK; ARM_MATH_CM3=true; SNSK2=E; __SAM3X8H__; SNSK1=F; _QTOUCH_; SNS2=E; SNS1=F
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/boards/sam3x_ek; ..; ../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../include; ../../../../../../../../common/services/serial; ../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../qdebug; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../common; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qtouch_example_flash.bin
  ILINK.IlinkOutputFile: qtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../lib/iar/: libsam3x-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/examples
    ../../: qtouch_example.c
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_example.h QDebugSettings.h
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../common/: BitBangSPI_Master.c touch_qt_config.h BitBangSPI_Master.h
  group thirdparty/qtouch/generic/include
    ../../../../../include/: touch_api.h
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebugTransport.c QDebug.c QDebug.h QDebugTransport.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c system_sam3x.h exceptions.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8h.h sam3xa.h sam3a4c.h sam3x8e.h sam3x4c.h sam3x8c.h sam3a8c.h sam3x4e.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../../../sam/utils/cmsis/sam3x/include/component/: component_supc.h component_smc.h component_pio.h component_can.h component_chipid.h component_hsmci.h component_dacc.h component_rtc.h component_uart.h component_pdc.h component_efc.h component_uotghs.h component_tc.h component_usart.h component_wdt.h component_pmc.h component_rstc.h component_pwm.h component_dmac.h component_gpbr.h component_twi.h component_spi.h component_sdramc.h component_trng.h component_rtt.h component_emac.h component_matrix.h component_ssc.h component_adc.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_spi1.h instance_adc.h instance_dmac.h instance_rtc.h instance_supc.h instance_dacc.h instance_piod.h instance_chipid.h instance_trng.h instance_uotghs.h instance_ssc.h instance_tc2.h instance_matrix.h instance_piob.h instance_emac.h instance_usart3.h instance_rstc.h instance_efc0.h instance_usart1.h instance_usart0.h instance_gpbr.h instance_hsmci.h instance_pioe.h instance_pmc.h instance_pwm.h instance_pioc.h instance_can0.h instance_pioa.h instance_usart2.h instance_efc1.h instance_uart.h instance_sdramc.h instance_piof.h instance_can1.h instance_smc.h instance_wdt.h instance_rtt.h instance_twi1.h instance_twi0.h instance_tc0.h instance_tc1.h instance_spi0.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3x8e.h pio_sam3x8h.h pio_sam3x8c.h pio_sam3a4c.h pio_sam3x4c.h pio_sam3x4e.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3x_ek
    ../../../../../../../../sam/boards/sam3x_ek/: led.c sam3x_ek.h led.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../../../../common/services/clock/sam3x/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
