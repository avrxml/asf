# IAR project samd_qtouch_mutlcap_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; RTC_COUNT_ASYNC=true; SYSTICK_MODE; TC_ASYNC=true; BOARD=SAMD21_XPLAINED_PRO; USART_CALLBACK_MODE=true; _QTOUCH_; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../qdebug; ..; ../../../../../../../../../common2/services/delay; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../../common/services/serial; ../../qtouch; ../../../../../../../../../sam0/drivers/rtc; ../../../../../../../../../common/utils; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../include; ../../../../../../../../../sam0/drivers/tc; ../../../../common; ../../../../../../../../../common2/services/delay/sam0; ../..; ../../../../../../../../../common/boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../..; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: samd_qtouch_mutlcap_example_flash.bin
  ILINK.IlinkOutputFile: samd_qtouch_mutlcap_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/sam0/samd/lib/iar
    ../../../../lib/iar/: libsamd21_qt_iar.a
  group thirdparty/qtouch/devspecific/sam0/samd/common
    ../../../../common/: BitBangSPI_Master.c BitBangSPI_Master.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap
    ../../: main.c
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap/qtouch
    ../../qtouch/: touch.c QDebugSettings.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap/samd21_xplained_pro
    ../: conf_board.h touch_config_samd.h conf_clocks.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap/samd21_xplained_pro/iar
    ./: asf.h
  group thirdparty/qtouch/devspecific/sam0/samd/include
    ../../../../include/: touch_api_SAMD.h
  group thirdparty/qtouch/qdebug
    ../../../../../../../qdebug/: QDebugTransport.c QDebug_samd.c QDebug_samd.h QDebugTransport.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/rtc
    ../../../../../../../../../sam0/drivers/rtc/: rtc_count.c rtc_count_interrupt.c rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/quick_start_count_callback
    ../../../../../../../../../sam0/drivers/rtc/quick_start_count_callback/: qs_rtc_count_callback.h
  group sam0/drivers/rtc/quick_start_count
    ../../../../../../../../../sam0/drivers/rtc/quick_start_count/: qs_rtc_count_basic.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/tc
    ../../../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.c tc.h tc_interrupt.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../../../../../../sam0/drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../../../../../../sam0/drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../../../../../../sam0/drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start
    ../../../../../../../../../sam0/drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21j16a.h samd21.h samd21g18a.h samd21g17a.h samd21e17a.h samd21e16a.h samd21j15a.h samd21g15a.h samd21e18a.h samd21j18a.h samd21j17a.h samd21e15a.h samd21g16a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21j15a.h samd21e15a.h samd21j18a.h samd21g15a.h samd21e16a.h samd21e17a.h samd21j17a.h samd21g16a.h samd21j16a.h samd21g18a.h samd21e18a.h samd21g17a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: port.h dmac.h evsys.h i2s.h tcc.h mtb.h pm.h tc.h wdt.h gclk.h pac.h rtc.h sysctrl.h usb.h dac.h dsu.h eic.h sercom.h ac.h nvmctrl.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac.h tcc1.h sercom3.h pac0.h pac2.h tc7.h mtb.h tc5.h adc.h tc3.h eic.h tcc2.h sercom1.h tcc0.h dac.h dsu.h i2s.h sercom4.h nvmctrl.h gclk.h wdt.h sercom0.h port.h pac1.h sercom2.h tc6.h evsys.h sysctrl.h dmac.h sercom5.h tc4.h usb.h pm.h rtc.h
  group sam0/utils/stdio
    ../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
