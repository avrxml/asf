# IAR project samd_qtouch_mutlcap_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; RTC_COUNT_ASYNC=true; BOARD=SAMD20_XPLAINED_PRO; SYSTICK_MODE; TC_ASYNC=true; USART_CALLBACK_MODE=true; _QTOUCH_; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../../../../sam0/drivers/port; ..; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../qdebug; ../../../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../../../../common2/services/delay; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../../common/services/serial; ../../qtouch; ../../../../../../../../../sam0/drivers/rtc; ../../../../../../../../../common/utils; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../include; ../../../../../../../../../sam0/drivers/tc; ../../../../common; ../../../../../../../../../common2/services/delay/sam0; ../..; ../../../../../../../../../common/boards; ../../../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../..; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: samd_qtouch_mutlcap_example_flash.bin
  ILINK.IlinkOutputFile: samd_qtouch_mutlcap_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/sam0/samd/lib/iar
    ../../../../lib/iar/: libsamd20_qt_iar.a
  group thirdparty/qtouch/devspecific/sam0/samd/common
    ../../../../common/: BitBangSPI_Master.c BitBangSPI_Master.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap
    ../../: main.c
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap/qtouch
    ../../qtouch/: touch.c QDebugSettings.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap/samd20_xplained_pro
    ../: conf_board.h touch_config_samd.h conf_clocks.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_mutlcap/samd20_xplained_pro/iar
    ./: asf.h
  group thirdparty/qtouch/devspecific/sam0/samd/include
    ../../../../include/: touch_api_SAMD.h
  group thirdparty/qtouch/qdebug
    ../../../../../../../qdebug/: QDebugTransport.c QDebug_samd.c QDebugTransport.h QDebug_samd.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../../../../../../sam0/drivers/rtc/: rtc_count.c rtc_count_interrupt.c rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/quick_start_count_callback
    ../../../../../../../../../sam0/drivers/rtc/quick_start_count_callback/: qs_rtc_count_callback.h
  group sam0/drivers/rtc/quick_start_count
    ../../../../../../../../../sam0/drivers/rtc/quick_start_count/: qs_rtc_count_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/tc
    ../../../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.c tc.h tc_interrupt.h
  group sam0/drivers/tc/quick_start
    ../../../../../../../../../sam0/drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../../../../../../sam0/drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../../../../../../sam0/drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../../../../../../sam0/drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../../../sam0/utils/cmsis/samd20/include/: samd20g17u.h samd20j15.h samd20g16.h samd20.h samd20e17.h samd20g15.h samd20j18.h samd20e18.h samd20e15.h samd20j16.h samd20g18.h samd20e16.h samd20j14.h samd20g14.h samd20g17.h samd20e14.h samd20j17.h samd20g18u.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd20/include/component/: tc.h adc.h pm.h evsys.h dac.h sysctrl.h nvmctrl.h eic.h dsu.h port.h rtc.h wdt.h ac.h pac.h sercom.h gclk.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20j15.h samd20j18.h samd20g17.h samd20j16.h samd20j14.h samd20g17u.h samd20g18.h samd20e18.h samd20e1f.h samd20e16.h samd20g14.h samd20e14.h samd20e17.h samd20g18u.h samd20g15.h samd20g16.h samd20j17.h samd20e15.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd20/include/instance/: evsys.h port.h pac2.h tc3.h nvmctrl.h rtc.h pac1.h pm.h sysctrl.h dsu.h pac0.h tc2.h sercom1.h tc1.h gclk.h eic.h dac.h sercom5.h tc5.h tc7.h sercom3.h sercom0.h tc0.h adc.h sercom4.h wdt.h ac.h tc4.h sercom2.h tc6.h
  group sam0/utils/stdio
    ../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
