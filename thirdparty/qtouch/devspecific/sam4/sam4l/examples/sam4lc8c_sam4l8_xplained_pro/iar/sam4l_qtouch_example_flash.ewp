# IAR project sam4l_qtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC8C__; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true; _QTOUCH_
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../qdebug; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ..; ../../../../../../../../common/services/serial; ../../../include; ../../../../../../../../sam/drivers/ast; ../../..; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../..; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../qtouch; ../../../../../../../../common/services/delay; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../sam/drivers/flashcalw; ../../../common; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/boards/sam4l8_xplained_pro; ../../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4l_qtouch_example_flash.bin
  ILINK.IlinkOutputFile: sam4l_qtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar
    ../../../lib/iar/: libsam4l-qt-iar.a
  group thirdparty/qtouch/devspecific/sam4/sam4l/examples
    ../../: main.c
  group thirdparty/qtouch/devspecific/sam4/sam4l/examples/qtouch
    ../../qtouch/: touch.c QDebugSettings.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/examples/sam4lc8c_sam4l8_xplained_pro
    ../: conf_ast.h conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h touch_config_sam4l.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/examples/sam4lc8c_sam4l8_xplained_pro/iar
    ./: asf.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/common
    ../../../common/: BitBangSPI_Master.c BitBangSPI_Master.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/include
    ../../../include/: touch_api_sam4l.h
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebug_sam4l.c QDebugTransport.c QDebug_sam4l.h QDebugTransport.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h dfll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c osc.c pll.c dfll.h osc.h genclk.h sysclk.h pll.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls4b.h sam4lc8b.h sam4lc4c.h sam4lc4a.h sam4l.h sam4lc2a.h sam4lc2c.h sam4ls2c.h sam4ls8c.h sam4lc8c.h sam4ls4c.h sam4ls4a.h sam4lc4b.h sam4lc2b.h sam4ls8a.h sam4ls2a.h sam4ls2b.h sam4ls8b.h sam4lc8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_tc1.h instance_acifc.h instance_hflashc.h instance_freqm.h instance_pevc.h instance_eic.h instance_chipid.h instance_usart2.h instance_bpm.h instance_trng.h instance_smap.h instance_abdacb.h instance_aesa.h instance_catb.h instance_twis0.h instance_parc.h instance_wdt.h instance_spi.h instance_twim0.h instance_ast.h instance_usart0.h instance_crccu.h instance_usart3.h instance_bscif.h instance_gpio.h instance_twim2.h instance_scif.h instance_adcife.h instance_lcdca.h instance_gloc.h instance_twis1.h instance_picouart.h instance_iisc.h instance_twim1.h instance_usart1.h instance_hcache.h instance_tc0.h instance_twim3.h instance_dacc.h instance_pdca.h instance_pm.h instance_hmatrix.h instance_usbc.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8c.h pio_sam4lc2b.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc4a.h pio_sam4lc4c.h pio_sam4ls8a.h pio_sam4ls4b.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4ls2a.h pio_sam4lc4b.h pio_sam4lc2c.h pio_sam4lc2a.h pio_sam4ls8b.h pio_sam4ls2b.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_flashcalw.h component_freqm.h component_parc.h component_usbc.h component_adcife.h component_lcdca.h component_ast.h component_twis.h component_spi.h component_twim.h component_crccu.h component_gloc.h component_hmatrixb.h component_bscif.h component_smap.h component_bpm.h component_eic.h component_usart.h component_trng.h component_hcache.h component_gpio.h component_tc.h component_scif.h component_pdca.h component_picouart.h component_abdacb.h component_pm.h component_iisc.h component_dacc.h component_pevc.h component_aesa.h component_catb.h component_acifc.h component_chipid.h component_wdt.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/ast
    ../../../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../../../../sam/boards/sam4l8_xplained_pro/: init.c sam4l8_xplained_pro.h led.h
