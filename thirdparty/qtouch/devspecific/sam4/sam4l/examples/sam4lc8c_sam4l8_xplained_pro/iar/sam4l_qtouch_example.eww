<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam4l_qtouch_example_flash.ewp</path>
	</project>
</workspace>
