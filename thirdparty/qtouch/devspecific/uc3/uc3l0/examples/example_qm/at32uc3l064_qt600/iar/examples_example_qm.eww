<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_example_qm.ewp</path>
	</project>
</workspace>
