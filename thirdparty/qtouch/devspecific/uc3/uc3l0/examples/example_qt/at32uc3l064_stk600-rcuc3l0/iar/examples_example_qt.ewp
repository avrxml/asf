# IAR project examples_example_qt.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=STK600_RCUC3L0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../../avr32/boards/stk600/rcuc3l0; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/drivers/tc; ../../../../../../../../../common/boards; ../../../../../../../../../avr32/drivers/usart; ../../../../common; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/utils; ../../../../include; ../..; ../../../../../../../../../common/utils; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/flashcdw; ../../../../../../../qdebug; ../../../../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=STK600_RCUC3L0
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar
    ../../../../lib/iar/: libuc3l-qtouch-iar.r82
  group thirdparty/qtouch/devspecific/uc3/uc3l0/common
    ../../../../common/: SPI_Master.c SPI_Master.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/examples/example_qt
    ../../: main.c touch_config_at32uc3l.h QDebugSettings.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/examples/example_qt/at32uc3l064_stk600-rcuc3l0/iar
    ./: asf.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/include
    ../../../../include/: touch_api_at32uc3l.h
  group thirdparty/qtouch/qdebug
    ../../../../../../../qdebug/: QDebugTransport.c QDebug_at32uc3l.c QDebugTransport.h QDebug_at32uc3l.h
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c sleep.h power_clocks_lib.h pm_uc3l.h
  group avr32/drivers/flashcdw
    ../../../../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/tc
    ../../../../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/stk600/rcuc3l0
    ../../../../../../../../../avr32/boards/stk600/rcuc3l0/: led.c stk600_rcuc3l0.h led.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
