<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\examples_example_qt.ewp</path>
	</project>
</workspace>
