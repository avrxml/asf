# IAR project examples_example_at.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/ast; ../../../../../../../../../avr32/utils/preprocessor; ../..; ../../../../../../../../../common/services/clock; ../../../../../../../../../avr32/boards/uc3_l0_xplained; ../../../../../../../../../common/boards; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usart; ..; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/utils; ../../../../include; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../../avr32/drivers/flashcdw; ../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar
    ../../../../lib/iar/: libuc3l-qtouch-iar.r82
  group thirdparty/qtouch/devspecific/uc3/uc3l0/examples/example_at
    ../../: main.c touch_config_at32uc3l.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/examples/example_at/at32uc3l064_uc3_l0_xplained
    ../: conf_board.h conf_sleepmgr.h conf_example.h conf_clock.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/examples/example_at/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/include
    ../../../../include/: touch_api_at32uc3l.h
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c sleep.h power_clocks_lib.h pm_uc3l.h
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/flashcdw
    ../../../../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/ast
    ../../../../../../../../../avr32/drivers/ast/: ast.c ast.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../../../../../avr32/boards/uc3_l0_xplained/: led.c led.h uc3_l0_xplained.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group common/services/sleepmgr
    ../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: sysclk.h osc.h dfll.h genclk.h
  group common/services/clock/uc3l
    ../../../../../../../../../common/services/clock/uc3l/: osc.c dfll.c sysclk.c sysclk.h genclk.h osc.h dfll.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
