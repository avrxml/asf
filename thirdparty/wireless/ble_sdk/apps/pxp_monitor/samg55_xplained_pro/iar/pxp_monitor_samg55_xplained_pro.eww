<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pxp_monitor_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
