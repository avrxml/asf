<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pxp_monitor_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
