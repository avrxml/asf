<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\find_me_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
