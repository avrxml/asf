<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ibeacon_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
