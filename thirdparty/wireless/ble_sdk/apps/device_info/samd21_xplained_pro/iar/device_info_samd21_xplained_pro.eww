<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_info_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
