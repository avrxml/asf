<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_info_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
