<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_info_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
