<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\device_info_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
