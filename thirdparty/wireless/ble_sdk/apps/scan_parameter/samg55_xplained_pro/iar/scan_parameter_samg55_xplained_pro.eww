<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\scan_parameter_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
