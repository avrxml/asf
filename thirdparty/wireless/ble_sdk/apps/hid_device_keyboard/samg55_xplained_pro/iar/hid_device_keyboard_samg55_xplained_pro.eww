<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hid_device_keyboard_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
