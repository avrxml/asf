<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hid_device_keyboard_saml21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
