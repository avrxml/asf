<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hid_device_keyboard_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
