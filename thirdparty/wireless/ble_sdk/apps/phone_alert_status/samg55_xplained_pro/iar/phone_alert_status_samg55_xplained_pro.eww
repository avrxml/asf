<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\phone_alert_status_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
