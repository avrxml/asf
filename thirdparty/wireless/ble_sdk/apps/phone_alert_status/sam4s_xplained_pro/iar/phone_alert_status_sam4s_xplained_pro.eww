<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\phone_alert_status_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
