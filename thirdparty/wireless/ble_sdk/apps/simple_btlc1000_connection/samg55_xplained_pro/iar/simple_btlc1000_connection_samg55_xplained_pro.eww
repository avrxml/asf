<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\simple_btlc1000_connection_samg55_xplained_pro_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\simple_btlc1000_connection_samg55_xplained_pro_sram.ewp</path>
	</project>
</workspace>
