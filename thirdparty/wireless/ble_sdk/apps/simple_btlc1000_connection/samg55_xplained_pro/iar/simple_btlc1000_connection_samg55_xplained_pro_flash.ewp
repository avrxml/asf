# IAR project simple_btlc1000_connection_samg55_xplained_pro_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..; ../../../../../../../sam/drivers/flexcom; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/efc; ../../../../../../../common/services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../inc; ../../../../../../../sam/utils/preprocessor; ../../../../services/serial/uart; ../../../../../../../sam/utils/fpu; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/supc; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../../../sam/utils/cmsis/samg/samg55/include; ../../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: simple_btlc1000_connection_samg55_xplained_pro_flash.bin
  ILINK.IlinkOutputFile: simple_btlc1000_connection_samg55_xplained_pro_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/samd21/iar
    ../../../../lib/samd21/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam
    ../../../../services/serial/uart/sam/: serial_drv.c
  group thirdparty/wireless/ble_sdk/apps/simple_btlc1000_connection
    ../../: main.c
  group thirdparty/wireless/ble_sdk/apps/simple_btlc1000_connection/samg55_xplained_pro
    ../: conf_serialdrv.h conf_clock.h conf_board.h conf_sleepmgr.h
  group thirdparty/wireless/ble_sdk/apps/simple_btlc1000_connection/samg55_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: platform.h at_ble_api.h profiles.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../../sam/boards/samg55_xplained_pro/: board_init.c led.h samg55_xplained_pro.h
  group sam/drivers/flexcom
    ../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h system_samg55.h samg55n19.h samg55g19.h samg55j18.h samg55j19.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: matrix.h efc.h chipid.h flexcom.h crccu.h pio.h adc.h i2sc.h supc.h twi.h mem2mem.h uhp.h gpbr.h cmcc.h rtt.h wdt.h tc.h pmc.h spi.h usart.h pdc.h udp.h pdmic.h rtc.h rstc.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: twi0.h usart7.h usart5.h matrix.h twi2.h i2sc1.h supc.h mem2mem.h flexcom4.h twi6.h flexcom6.h udp.h pioa.h gpbr.h flexcom0.h spi1.h usart4.h spi2.h usart6.h pmc.h flexcom2.h rtt.h twi3.h twi5.h tc1.h flexcom5.h spi6.h twi7.h i2sc0.h flexcom7.h usart2.h spi4.h flexcom1.h spi3.h rtc.h usart3.h efc.h flexcom3.h pdmic1.h adc.h tc0.h cmcc.h spi7.h twi1.h crccu.h spi5.h usart1.h usart0.h rstc.h piob.h wdt.h pdmic0.h twi4.h chipid.h uhp.h spi0.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55j18.h samg55n19.h samg55g19.h samg55j19.h samg55g18.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samg
    ../../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
