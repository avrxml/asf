<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\multirole_peripheral_multiconnect_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
