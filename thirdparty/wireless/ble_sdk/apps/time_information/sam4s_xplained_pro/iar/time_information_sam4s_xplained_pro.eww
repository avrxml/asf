<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\time_information_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
