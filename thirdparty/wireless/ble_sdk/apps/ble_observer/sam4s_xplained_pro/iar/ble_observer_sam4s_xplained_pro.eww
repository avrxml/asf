<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ble_observer_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
