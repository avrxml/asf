<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ble_observer_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
