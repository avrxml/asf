<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\battery_info_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
