<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\alert_notification_saml21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
