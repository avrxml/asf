<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\alert_notification_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
