<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hid_device_mouse_samg55_xplained_pro_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\hid_device_mouse_samg55_xplained_pro_sram.ewp</path>
	</project>
</workspace>
