<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\blood_pressure_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
