<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\custom_serial_chat_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
