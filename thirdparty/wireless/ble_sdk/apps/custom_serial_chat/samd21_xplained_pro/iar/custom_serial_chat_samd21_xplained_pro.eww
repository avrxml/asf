<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\custom_serial_chat_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
