<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\custom_serial_chat_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
