<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hr_sensor_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
