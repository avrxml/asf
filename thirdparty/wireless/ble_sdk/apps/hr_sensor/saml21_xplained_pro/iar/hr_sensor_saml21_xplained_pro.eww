<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hr_sensor_saml21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
