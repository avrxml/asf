<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hr_sensor_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
