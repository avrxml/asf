<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\htpt_temperature_sensor_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
