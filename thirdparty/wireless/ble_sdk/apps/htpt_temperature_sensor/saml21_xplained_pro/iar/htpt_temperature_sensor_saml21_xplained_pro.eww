<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\htpt_temperature_sensor_saml21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
