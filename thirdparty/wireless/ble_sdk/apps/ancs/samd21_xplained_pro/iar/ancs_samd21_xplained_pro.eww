<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ancs_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
