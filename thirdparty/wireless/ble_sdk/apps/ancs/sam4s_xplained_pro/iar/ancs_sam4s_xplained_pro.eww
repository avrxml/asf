<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ancs_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
