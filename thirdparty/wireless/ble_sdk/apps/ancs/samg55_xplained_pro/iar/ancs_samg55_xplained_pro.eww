<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ancs_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
