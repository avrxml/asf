<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\l2cap_peripheral_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
