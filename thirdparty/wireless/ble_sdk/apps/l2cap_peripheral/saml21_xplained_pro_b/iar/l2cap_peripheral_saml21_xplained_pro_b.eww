<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\l2cap_peripheral_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
