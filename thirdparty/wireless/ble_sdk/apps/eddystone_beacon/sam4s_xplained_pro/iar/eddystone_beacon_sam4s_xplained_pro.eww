<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eddystone_beacon_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
