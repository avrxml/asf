<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eddystone_beacon_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
