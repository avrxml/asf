<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eddystone_beacon_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
