<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pxp_reporter_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
