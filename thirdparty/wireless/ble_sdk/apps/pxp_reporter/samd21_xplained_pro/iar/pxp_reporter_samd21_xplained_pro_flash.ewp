# IAR project pxp_reporter_samd21_xplained_pro_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HOST_UART_BAUDRATE_CONFIG_VALUE=921600; NENABLE_PTS; LINK_LOSS_SERVICE; TX_POWER_SERVICE; UART_FLOWCONTROL_4WIRE_MODE=false; TXPS_GATT_SERVER; SLEEP_WALKING_ENABLED=false; TC_ASYNC=true; ATT_DB_MEMORY; BLE_DEVICE_ROLE=BLE_ROLE_PERIPHERAL; ARM_MATH_CM0PLUS=true; ENABLE_POWER_SAVE; LLS_GATT_SERVER; BOARD=SAMD21_XPLAINED_PRO; BLE_MODULE=BTLC1000_MR; EXTINT_CALLBACK_MODE=true; IMMEDIATE_ALERT_SERVICE; UART_FLOWCONTROL_6WIRE_MODE=true; USART_CALLBACK_MODE=true; PROXIMITY_REPORTER; NEW_EVT_HANDLER; SYSTICK_MODE; IAS_GATT_SERVER; __SAMD21J18A__; HOST_SLEEP_ENABLE=true
  ICCARM.CCIncludePath2: ../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../sam0/drivers/system/interrupt; ../../../config/samd21; ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../ble_services/ble_mgr; ../../../../../../../sam0/utils/preprocessor; ../..; ../../../../ble_services/link_loss; ../../../../ble_services/tx_power; ../../../../../../../sam0/utils; ../../../../services/timer; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../services/serial/uart; ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../sam0/drivers/tc; ../../../../inc; ../../../../../../../common2/services/delay/sam0; ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../utils; ../../../../../../../common2/services/delay; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/pinmux; ../../../../services/console; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/drivers/extint; ../../../../services/serial_fifo; ../../../../../../../sam0/utils/header_files; ../../../../ble_services/immediate_alert; ../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../ble_profiles/pxp_reporter; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pxp_reporter_samd21_xplained_pro_flash.bin
  ILINK.IlinkOutputFile: pxp_reporter_samd21_xplained_pro_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/cm0p/iar
    ../../../../lib/cm0p/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/apps/pxp_reporter
    ../../: pxp_reporter_app.c pxp_reporter_app.h
  group thirdparty/wireless/ble_sdk/apps/pxp_reporter/samd21_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/apps/config/samd21
    ../../../config/samd21/: conf_console.h conf_timer.h conf_serialdrv.h conf_extint.h conf_clocks.h conf_board.h
  group thirdparty/wireless/ble_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_sdk/services/timer/sam0
    ../../../../services/timer/sam0/: timer_hw.c
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam0
    ../../../../services/serial/uart/sam0/: serial_drv.c
  group thirdparty/wireless/ble_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_sdk/services/console/sam0
    ../../../../services/console/sam0/: console_serial.c
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/ble_services/tx_power
    ../../../../ble_services/tx_power/: tx_power.c tx_power.h
  group thirdparty/wireless/ble_sdk/ble_services/link_loss
    ../../../../ble_services/link_loss/: link_loss.c link_loss.h
  group thirdparty/wireless/ble_sdk/ble_services/immediate_alert
    ../../../../ble_services/immediate_alert/: immediate_alert.c immediate_alert.h
  group thirdparty/wireless/ble_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_sdk/ble_profiles/pxp_reporter
    ../../../../ble_profiles/pxp_reporter/: pxp_reporter.c pxp_reporter.h
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: at_ble_trace.h platform.h at_ble_api.h at_ble_errno.h profiles.h
  group thirdparty/wireless/ble_sdk/utils
    ../../../../utils/: ble_utils.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_interrupt.h sercom_pinout.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../sam0/utils/cmsis/samd21/include/: samd21.h samd21g18a.h samd21j18a.h samd21j15a.h samd21g18au.h samd21g16b.h samd21e16a.h samd21j16b.h samd21e18a.h samd21e17du.h samd21j15b.h samd21g17d.h samd21e16l.h samd21e16b.h samd21e17a.h samd21e15b.h samd21e15l.h samd21g17l.h samd21g15a.h samd21j17a.h samd21e15bu.h samd21e16bu.h samd21g17a.h samd21g16l.h samd21j17d.h samd21e17d.h samd21e15a.h samd21g15b.h samd21j16a.h samd21g15l.h samd21e17l.h samd21g17au.h samd21g16a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../sam0/utils/cmsis/samd21/include/instance/: nvmctrl.h i2s.h mtb.h sysctrl.h ac1.h tcc1.h adc.h dsu.h eic.h nvmctrl_variant_d.h pm.h tc6.h tc4.h dac.h pac2.h wdt.h sercom4.h evsys_variant_d.h sercom2.h tcc3.h pac0.h sercom1.h sbmatrix.h tc7.h tcc0.h tc5.h sercom5.h tcc2.h sercom3.h evsys.h pac1.h rtc.h port.h ac.h sercom0.h dmac.h usb.h gclk.h port_variant_d.h tc3.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g18au.h samd21e15bu.h samd21j17a.h samd21e15b.h samd21g17a.h samd21e16b.h samd21j15b.h samd21e16l.h samd21j16a.h samd21g16b.h samd21e17a.h samd21g17d.h samd21g18a.h samd21j18a.h samd21e17l.h samd21j16b.h samd21e17du.h samd21g16a.h samd21e18a.h samd21j15a.h samd21j17d.h samd21g15a.h samd21e15l.h samd21e16bu.h samd21g15b.h samd21g15l.h samd21g16l.h samd21e17d.h samd21g17au.h samd21e16a.h samd21e15a.h samd21g17l.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../sam0/utils/cmsis/samd21/include/component/: tcc_lighting.h tcc.h i2s.h nvmctrl.h evsys.h adc.h ac.h rtc.h port.h pm.h pac.h gclk.h tc.h usb.h sysctrl.h tcc_variant_d.h pm_variant_d.h mtb.h dac.h eic.h dmac.h hmatrixb.h dsu.h sercom.h evsys_variant_d.h nvmctrl_variant_d.h wdt.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
