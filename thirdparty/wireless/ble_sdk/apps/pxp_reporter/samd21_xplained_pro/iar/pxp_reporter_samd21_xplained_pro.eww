<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pxp_reporter_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
