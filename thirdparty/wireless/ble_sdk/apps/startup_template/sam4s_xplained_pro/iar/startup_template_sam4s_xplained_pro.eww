<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\startup_template_sam4s_xplained_pro_flash.ewp</path>
	</project>
</workspace>
