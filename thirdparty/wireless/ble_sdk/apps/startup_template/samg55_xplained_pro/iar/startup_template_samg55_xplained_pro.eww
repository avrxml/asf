<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\startup_template_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
