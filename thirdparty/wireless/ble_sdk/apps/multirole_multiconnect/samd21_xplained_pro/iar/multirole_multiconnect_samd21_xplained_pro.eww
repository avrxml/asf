<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\multirole_multiconnect_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
