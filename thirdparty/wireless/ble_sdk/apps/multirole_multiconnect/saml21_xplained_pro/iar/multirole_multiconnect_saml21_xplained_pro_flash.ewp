# IAR project multirole_multiconnect_saml21_xplained_pro_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; IAS_GATT_CLIENT; NEW_EVT_HANDLER; TC_ASYNC=true; __SAML21J18A__; EXTINT_CALLBACK_MODE=true; IMMEDIATE_ALERT_SERVICE; UART_FLOWCONTROL_6WIRE_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; BATTERY_SERVICE; LLS_GATT_CLIENT; BLE_DEVICE_ROLE=BLE_ROLE_ALL; UART_FLOWCONTROL_4WIRE_MODE=false; TXPS_GATT_CLIENT; LINK_LOSS_SERVICE; BOARD=SAML21_XPLAINED_PRO; TX_POWER_SERVICE; PROXIMITY_MONITOR; ENABLE_POWER_SAVE
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/boards/saml21_xplained_pro; ../../../../ble_profiles/pxp_monitor; ../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../ble_services/ble_mgr; ../../../../../../../sam0/utils/preprocessor; ../../../../ble_services/link_loss; ../../../../ble_services/tx_power; ../../../../ble_services/battery; ../../../../../../../sam0/utils; ../../../../services/timer; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../services/console; ../../../../../../../common/services/serial; ../../../config/saml21; ../../../../services/serial/uart; ../../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/drivers/tc; ../../../../inc; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../common2/services/delay/sam0; ../../../../../../../sam0/drivers/sercom/usart; ../..; ../../../../utils; ../../../../../../../common2/services/delay; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/utils/cmsis/saml21/include; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/drivers/extint; ../../../../services/serial_fifo; ../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../ble_services/immediate_alert; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: multirole_multiconnect_saml21_xplained_pro_flash.bin
  ILINK.IlinkOutputFile: multirole_multiconnect_saml21_xplained_pro_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/cm0p/iar
    ../../../../lib/cm0p/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_sdk/services/timer/sam0
    ../../../../services/timer/sam0/: timer_hw.c
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam0
    ../../../../services/serial/uart/sam0/: serial_drv.c
  group thirdparty/wireless/ble_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_sdk/services/console/sam0
    ../../../../services/console/sam0/: console_serial.c
  group thirdparty/wireless/ble_sdk/ble_services/immediate_alert
    ../../../../ble_services/immediate_alert/: immediate_alert.c immediate_alert.h
  group thirdparty/wireless/ble_sdk/ble_services/tx_power
    ../../../../ble_services/tx_power/: tx_power.c tx_power.h
  group thirdparty/wireless/ble_sdk/ble_services/link_loss
    ../../../../ble_services/link_loss/: link_loss.c link_loss.h
  group thirdparty/wireless/ble_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_sdk/ble_services/battery
    ../../../../ble_services/battery/: battery.c battery.h
  group thirdparty/wireless/ble_sdk/apps/multirole_multiconnect
    ../../: multirole_multiconnect.c multirole_multiconnect.h
  group thirdparty/wireless/ble_sdk/apps/multirole_multiconnect/saml21_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/apps/config/saml21
    ../../../config/saml21/: conf_extint.h conf_timer.h conf_console.h conf_serialdrv.h conf_clocks.h conf_board.h
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/ble_profiles/pxp_monitor
    ../../../../ble_profiles/pxp_monitor/: pxp_monitor.c pxp_monitor.h
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: platform.h at_ble_errno.h at_ble_api.h at_ble_trace.h profiles.h
  group thirdparty/wireless/ble_sdk/utils
    ../../../../utils/: ble_utils.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../sam0/utils/cmsis/saml21/include/: saml21.h saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../sam0/utils/cmsis/saml21/include/component/: evsys.h osc32kctrl.h rtc_100.h tc_100.h gclk_100.h dsu.h port.h aes.h usb.h mclk_100.h wdt.h trng.h mtb.h supc_100.h pac_100.h ccl.h opamp.h nvmctrl_301.h ac.h dmac.h oscctrl.h rstc_100.h adc_100.h dac.h tcc_200.h sercom.h pm_100.h tal.h eic_100.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include/instance/: sercom1.h mtb.h ac.h opamp.h wdt.h osc32kctrl.h aes.h port.h sercom5.h eic_100.h tc4_100.h tc0_100.h usb.h tal.h dmac.h rtc_100.h dac.h oscctrl.h tc3_100.h tcc2_200.h rstc_100.h dsu.h adc_100.h mclk_100.h pm_100.h tc1_100.h tcc1_200.h gclk_100.h tcc0_200.h sercom4.h supc_100.h sercom2.h sercom0.h tc2_100.h ccl.h nvmctrl_301.h pac_100.h evsys.h trng.h sercom3.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h stringz.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
