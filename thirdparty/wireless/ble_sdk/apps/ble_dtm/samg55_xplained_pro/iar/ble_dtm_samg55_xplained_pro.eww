<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ble_dtm_samg55_xplained_pro_flash.ewp</path>
	</project>
</workspace>
