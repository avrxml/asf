<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ble_dtm_saml21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
