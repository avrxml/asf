<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ble_dtm_sam4s_xplained_pro_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ble_dtm_sam4s_xplained_pro_sram.ewp</path>
	</project>
</workspace>
