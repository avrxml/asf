<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\l2cap_central_samd21_xplained_pro_flash.ewp</path>
	</project>
</workspace>
