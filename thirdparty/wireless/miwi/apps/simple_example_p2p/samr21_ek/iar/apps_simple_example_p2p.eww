<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_simple_example_p2p_flash.ewp</path>
	</project>
</workspace>
