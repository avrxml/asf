<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_wsn_demo_flash.ewp</path>
	</project>
</workspace>
