<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_chat_demo_flash.ewp</path>
	</project>
</workspace>
