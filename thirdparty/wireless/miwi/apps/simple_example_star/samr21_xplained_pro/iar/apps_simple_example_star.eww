<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_simple_example_star_flash.ewp</path>
	</project>
</workspace>
