<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tal_unit_tests.ewp</path>
	</project>
</workspace>
