<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tfa_unit_tests.ewp</path>
	</project>
</workspace>
