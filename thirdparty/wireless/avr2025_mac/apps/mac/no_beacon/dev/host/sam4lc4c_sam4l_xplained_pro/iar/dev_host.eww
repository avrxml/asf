<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dev_host_flash.ewp</path>
	</project>
</workspace>
