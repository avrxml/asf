<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dev_ncp.ewp</path>
	</project>
</workspace>
