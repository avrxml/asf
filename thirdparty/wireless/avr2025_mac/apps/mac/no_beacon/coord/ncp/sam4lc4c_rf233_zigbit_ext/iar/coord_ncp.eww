<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\coord_ncp_flash.ewp</path>
	</project>
</workspace>
