<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\coord_ncp.ewp</path>
	</project>
</workspace>
