<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nobcn_ffd_host_flash.ewp</path>
	</project>
</workspace>
