# IAR project no_bcn_ffd_host_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FFD; TEST_HARNESS; BOARD=SAM4L_XPLAINED_PRO; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../../../../../../../source/mac/inc; ../../../../../../../addons/api_parser/inc; ../../../../../../../../../../common/boards; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../../../common/services/serial; ..; ../../../../../../../../../../common/utils; ../../../../../../../../addons/sio2ncp/uart; ../../../../../../../../../../sam/drivers/wdt; ../..; ../../../../../../../addons/serial_if/inc; ../../../../../../../../../../common/services/clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../addons/sio2host/uart; ../../../../../../../source/pal/common_hw_timer; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../sam/utils; ../../../../../../../../../../sam/drivers/tc; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../sam/drivers/bpm; ../../../..; ../../../../../../../source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: no_bcn_ffd_host_flash.bin
  ILINK.IlinkOutputFile: no_bcn_ffd_host_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../../source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../../source/pal/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../../source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac_api.h mac_msg_type_data_ind.h mac_msg_types.h mac_msg_const.h mac.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/no_bcn_ffd/host
    ../../: app_config.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/no_bcn_ffd/host/sam4lc4c_sam4l_xplained_pro
    ../: conf_sio2host.h conf_clock.h conf_hw_timer.h conf_board.h conf_uart_serial.h conf_sio2ncp.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/no_bcn_ffd/host/sam4lc4c_sam4l_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/inc
    ../../../../../../../addons/serial_if/inc/: private_const.h serial_interface.h
  group thirdparty/wireless/avr2025_mac/addons/api_parser/src
    ../../../../../../../addons/api_parser/src/: api_decoder.c api_encoder.c
  group thirdparty/wireless/avr2025_mac/addons/api_parser/inc
    ../../../../../../../addons/api_parser/inc/: api_parser.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h ieee_const.h mac_build_config.h stack_config.h return_val.h tal_build_config.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../../../../../addons/sio2ncp/uart/: sio2ncp.c sio2ncp.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/utils
    ../../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../../../../../common/services/clock/: pll.h genclk.h sysclk.h dfll.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c pll.c osc.c dfll.h osc.h genclk.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/tc
    ../../../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
