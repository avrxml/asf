<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nobcn_ffd_ncp.ewp</path>
	</project>
</workspace>
