<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\no_bcn_ffd_ncp.ewp</path>
	</project>
</workspace>
