<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nobcn_ffd_ncp_flash.ewp</path>
	</project>
</workspace>
