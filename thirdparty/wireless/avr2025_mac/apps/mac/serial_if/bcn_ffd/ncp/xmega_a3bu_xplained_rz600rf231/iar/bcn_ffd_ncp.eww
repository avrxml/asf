<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bcn_ffd_ncp.ewp</path>
	</project>
</workspace>
