<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bcn_ffd_ncp_flash.ewp</path>
	</project>
</workspace>
