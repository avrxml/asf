<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bcn_ffd_host_flash.ewp</path>
	</project>
</workspace>
