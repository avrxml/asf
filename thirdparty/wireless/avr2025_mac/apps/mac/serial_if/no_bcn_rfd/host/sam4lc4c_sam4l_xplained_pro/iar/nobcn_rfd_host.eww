<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nobcn_rfd_host_flash.ewp</path>
	</project>
</workspace>
