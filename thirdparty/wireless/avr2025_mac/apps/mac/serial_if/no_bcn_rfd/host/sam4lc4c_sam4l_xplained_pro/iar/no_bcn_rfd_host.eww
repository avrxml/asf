<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\no_bcn_rfd_host_flash.ewp</path>
	</project>
</workspace>
