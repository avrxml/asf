<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nobcn_rfd_ncp.ewp</path>
	</project>
</workspace>
