<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\no_bcn_rfd_ncp_flash.ewp</path>
	</project>
</workspace>
