<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nobcn_rfd_ncp_flash.ewp</path>
	</project>
</workspace>
