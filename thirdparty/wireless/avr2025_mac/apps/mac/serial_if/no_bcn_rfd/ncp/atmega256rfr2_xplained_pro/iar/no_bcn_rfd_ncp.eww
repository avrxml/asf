<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\no_bcn_rfd_ncp.ewp</path>
	</project>
</workspace>
