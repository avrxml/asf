<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bcn_rfd_ncp.ewp</path>
	</project>
</workspace>
