# IAR project bcn_rfd_ncp_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; TEST_HARNESS; ANTENNA_DIVERSITY=1; SPI_CALLBACK_MODE=false; BOARD=SAMR21_XPLAINED_PRO; TAL_TYPE=AT86RF233; _DEBUG_=0; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; HIGHEST_STACK_LAYER=MAC; __SAMR21G18A__; ENABLE_TSTAMP; GTS_SUPPORT; STB_ON_SAL; SAL_TYPE=AT86RF2xx; SYSTICK_MODE; BEACON_SUPPORT; USART_CALLBACK_MODE=false; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21; ../../../../../../../source/mac/inc; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/utils/cmsis/samr21/include/instance; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../../../../sam0/utils/cmsis/samr21/source; ../../../../../../../../services/sal/inc; ../../../../../../../../../../common2/services/delay; ../../../../../../../source/resources/queue/inc; ../../../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../services/trx_access; ../../../../../../../include; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../services/common_hw_timer/sam0; ../../../../../../../../../../common/services/serial; ../..; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/utils; ../../../../../../../source/tal/at86rf233/inc; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/tc; ../../../../../../../addons/serial_if/inc; ../../../../../../../source/pal; ..; ../../../../../../../../../../sam0/utils/cmsis/samr21/include/pio; ../../../../../../../../../../sam0/utils/cmsis/samr21/include/component; ../../../../../../../../services/common_hw_timer; ../../../../../../../source/stb/inc; ../../../../../../../source/tal/inc; ../../../../../../../../addons/sio2host/uart; ../../../../../../../../../../common2/services/delay/sam0; ../../../../../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../../../../../sam0/utils/cmsis/samr21/include; ../../../../../../../../../../common/boards; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../../sam0/utils/header_files; ../../../..; ../../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bcn_rfd_ncp_flash.bin
  ILINK.IlinkOutputFile: bcn_rfd_ncp_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../../../../services/sal/inc/: sal.h sal_generic.h sal_types.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_pib.c mac_beacon.c mac_associate.c mac_poll.c mac_mcps_data.c mac_data_ind.c mac_orphan.c mac.c mac_start.c mac_scan.c mac_sync.c mac_misc.c mac_dispatcher.c mac_rx_enable.c mac_process_beacon_frame.c mac_callback_wrapper.c mac_gts.c mac_disassociate.c mac_security.c mac_api.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_tx_coord_realignment_command.c mac_data_extract_mhr.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac_internal.h mac_api.h mac_msg_type_data_ind.h mac_msg_types.h mac_msg_const.h mac_security.h mac_data_structures.h mac.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal.c tal_rx.c tal_ed.c tal_pwr_mgmt.c tal_slotted_csma.c tal_pib.c tal_irq_handler.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../../../source/tal/at86rf233/inc/: tal_tx.h tal_config.h tal_pib.h at86rf233.h tal_irq_handler.h tal_constants.h tal_slotted_csma.h tal_rx.h tal_internal.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../source/tal/inc/: tal.h tal_helper.h tal_timer_config.h tal_types.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal_generic.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../source/stb/src/: stb_help.c stb.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../source/stb/inc/: stb_armcrypto.h stb_internal.h stb.h stb_generic.h
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/inc
    ../../../../../../../addons/serial_if/inc/: private_const.h serial_interface.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_rfd/ncp
    ../../: app_config.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_rfd/ncp/samr21_xpro
    ../: conf_sio2host.h conf_board.h conf_spi.h conf_clocks.h conf_hw_timer.h conf_extint.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_rfd/ncp/samr21_xpro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h stack_config.h ieee_const.h return_val.h tal_build_config.h mac_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/utils
    ../../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.c extint.h extint_callback.h
  group sam0/drivers/extint/quick_start_polled
    ../../../../../../../../../../sam0/drivers/extint/quick_start_polled/: qs_extint_basic.h
  group sam0/drivers/extint/quick_start_callback
    ../../../../../../../../../../sam0/drivers/extint/quick_start_callback/: qs_extint_callback.h
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/sercom
    ../../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/tc
    ../../../../../../../../../../sam0/drivers/tc/: tc.c tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/quick_start
    ../../../../../../../../../../sam0/drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../../../../../../../sam0/drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../../../../../../../sam0/drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../../../../../../../sam0/drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/: samr21e18a.h samr21g18a.h samr21g16a.h samr21e16a.h samr21g17a.h samr21e17a.h samr21.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/instance/: instance_sercom5.h instance_eic.h instance_sercom1.h instance_sercom3.h instance_adc.h instance_pac0.h instance_tc5.h instance_tc3.h instance_sercom4.h instance_gclk.h instance_tcc2.h instance_sercom0.h instance_tc7.h instance_sercom2.h instance_tcc1.h instance_port.h instance_wdt.h instance_pac1.h instance_ac.h instance_tc4.h instance_tcc0.h instance_rfctrl.h instance_usb.h instance_nvmctrl.h instance_tc6.h instance_rtc.h instance_pm.h instance_dsu.h instance_i2s.h instance_dmac.h instance_mtb.h instance_sysctrl.h instance_pac2.h instance_evsys.h instance_dac.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/component/: component_evsys.h component_rfctrl.h component_mtb.h component_tcc.h component_tc.h component_sysctrl.h component_dmac.h component_ac.h component_dsu.h component_dac.h component_nvmctrl.h component_sercom.h component_adc.h component_usb.h component_rtc.h component_i2s.h component_pm.h component_wdt.h component_eic.h component_port.h component_pac.h component_gclk.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/pio/: pio_samr21g18a.h pio_samr21e18a.h pio_samr21g16a.h pio_samr21e16a.h pio_samr21e17a.h pio_samr21g17a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h mrecursion.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
