<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bcn_rfd_ncp_flash.ewp</path>
	</project>
</workspace>
