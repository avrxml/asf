# IAR project bcn_rfd_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: TEST_HARNESS; STB_ON_SAL; _DEBUG_=0; IOPORT_XMEGA_COMPAT; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; GTS_SUPPORT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; TAL_TYPE=AT86RF212B; BOARD=XMEGA_RF212B_ZIGBIT; BEACON_SUPPORT; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../source/mac/inc; ../../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../../../xmega/drivers/tc; ../../../../../../../../../../xmega/utils; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../../../../xmega/boards/xmega_rf212b_zigbit; ../../../../../../../../services/sal/inc; ../../../../../../../source/resources/queue/inc; ../../../../../../../source/tal/inc; ../../../../../../../../services/trx_access; ../../../../../../../include; ../../../../../../../source/stb/inc; ../../../../../../../../../../common/services/gpio; ../../../../../../../../../../common/services/ioport; ../../../../../../../../addons/sio2host/usb; ../../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../../common/utils; ../../../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../addons/serial_if/inc; ../../../../../../../../../../common/services/clock; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/services/usb; ../../../../../../../../services/common_hw_timer; ../../../../../../../../../../xmega/boards; ..; ../../../../../../../source/tal/at86rf212b/inc; ../../../../../../../source/pal; ../../../../../../../../services/common_hw_timer/xmega; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../common/services/usb/udc; ../../../../../../../../../../xmega/drivers/usb; ../../../../../../../../../../common/services/spi; ../../../../../../../../../../common/boards; ../../../../../../../../../../xmega/drivers/spi; ../..; ../../../..; ../../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; TEST_HARNESS; STB_ON_SAL; _DEBUG_=0; IOPORT_XMEGA_COMPAT; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; GTS_SUPPORT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; TAL_TYPE=AT86RF212B; BOARD=XMEGA_RF212B_ZIGBIT; BEACON_SUPPORT; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/atxmega_sal/src
    ../../../../../../../../services/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/src
    ../../../../../../../source/tal/at86rf212b/src/: tal_pib.c tal_ed.c tal.c tal_slotted_csma.c tal_rx_enable.c tal_pwr_mgmt.c tal_init.c tal_rx.c tal_irq_handler.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/inc
    ../../../../../../../source/tal/at86rf212b/inc/: tal_constants.h tal_rx.h at86rf212b.h tal_irq_handler.h tal_config.h tal_internal.h tal_slotted_csma.h tal_tx.h tal_pib.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../source/tal/inc/: tal.h tal_helper.h tal_timer_config.h tal_types.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_beacon.c mac_associate.c mac_poll.c mac_mcps_data.c mac_orphan.c mac.c mac_start.c mac_scan.c mac_sync.c mac_gts.c mac_misc.c mac_dispatcher.c mac_rx_enable.c mac_callback_wrapper.c mac_pib.c mac_data_ind.c mac_data_extract_mhr.c mac_disassociate.c mac_security.c mac_api.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_tx_coord_realignment_command.c mac_process_beacon_frame.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac_internal.h mac_api.h mac_msg_type_data_ind.h mac_msg_types.h mac_msg_const.h mac_security.h mac_data_structures.h mac.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal_generic.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../source/stb/src/: stb_help.c stb_armcrypto.c stb.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../source/stb/inc/: stb_armcrypto.h stb_internal.h stb.h stb_generic.h
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/inc
    ../../../../../../../addons/serial_if/inc/: private_const.h serial_interface.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_rfd/ncp
    ../../: app_config.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_rfd/ncp/atxmega256a3u_rf212b_zigbit_usb
    ../: conf_sio2host.h conf_board.h conf_clock.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_rfd/ncp/atxmega256a3u_rf212b_zigbit_usb/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h stack_config.h ieee_const.h return_val.h tal_build_config.h mac_build_config.h ieee_154g.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group common/services/spi
    ../../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/usb
    ../../../../../../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../../../../../common/services/usb/udc/: udc.c udi.h udc.h udc_desc.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../../../../../common/services/clock/: sysclk.h genclk.h osc.h pll.h
  group common/services/clock/xmega
    ../../../../../../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group xmega/drivers/spi
    ../../../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/tc
    ../../../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/boards/xmega_rf212b_zigbit
    ../../../../../../../../../../xmega/boards/xmega_rf212b_zigbit/: init.c xmega_rf212b_zigbit.h led.h
  group xmega/utils
    ../../../../../../../../../../xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/bit_handling
    ../../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group xmega/utils/assembler
    ../../../../../../../../../../xmega/utils/assembler/: iar.h
