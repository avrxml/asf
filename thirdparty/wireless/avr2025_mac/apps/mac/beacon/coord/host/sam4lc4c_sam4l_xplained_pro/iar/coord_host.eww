<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\coord_host_flash.ewp</path>
	</project>
</workspace>
