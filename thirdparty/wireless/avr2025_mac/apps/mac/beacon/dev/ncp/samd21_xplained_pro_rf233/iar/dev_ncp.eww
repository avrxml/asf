<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dev_ncp_flash.ewp</path>
	</project>
</workspace>
