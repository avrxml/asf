<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mac_no_beacon_sleep.ewp</path>
	</project>
</workspace>
