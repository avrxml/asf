# IAR project mac_no_beacon_sleep.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: FFD; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; TAL_TYPE=AT86RF230B; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../source/pal/common_hw_timer/xmega; ../..; ../../../../../source/mac/inc; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/utils; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../source/tal/at86rf230b/inc; ../../../../../include; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../common/services/clock; ../../../../../source/resources/buffer/inc; ..; ../../../../../../../../xmega/boards; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/gpio; ../../../../../source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../xmega/drivers/spi; ../../../../../../../../common/services/ioport; ../../../../../../../../xmega/drivers/sleep; ../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; TAL_TYPE=AT86RF230B; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal_ext_trx.c pal.h pal_generic.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../../source/pal/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../../source/pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../source/mac/src/: mac_tx_coord_realignment_command.c mac_poll.c mac_process_tal_tx_frame_status.c mac_associate.c mac_data_extract_mhr.c mac_beacon.c mac_data_req.c mac_scan.c mac_misc.c mac_process_beacon_frame.c mac_data_ind.c mac_security.c mac_start.c mac_api.c mac_orphan.c mac_disassociate.c mac_mcps_data.c mac_pib.c mac_sync.c mac_dispatcher.c mac.c mac_callback_wrapper.c mac_rx_enable.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_msg_type_data_ind.h mac_data_structures.h mac.h mac_internal.h mac_api.h mac_config.h mac_msg_const.h mac_security.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf230b/src
    ../../../../../source/tal/at86rf230b/src/: tal.c tal_init.c tal_slotted_csma.c tal_pib.c tal_irq_handler.c tal_pwr_mgmt.c tal_rx.c tal_ed.c tal_rx_enable.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf230b/inc
    ../../../../../source/tal/at86rf230b/inc/: tal_constants.h tal_irq_handler.h tal_tx.h tal_rx.h tal_internal.h tal_slotted_csma.h tal_pib.h at86rf230b.h tal_config.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep
    ../../: main.c app_config.h conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep/xmega_a3bu_xplained_rz600rf230b
    ../: conf_board.h conf_clock.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep/xmega_a3bu_xplained_rz600rf230b/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: avr2025_mac.h mac_build_config.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../../common/services/clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/utils
    ../../../../../../../../xmega/utils/: assembler.h status_codes.h progmem.h compiler.h
  group xmega/utils/assembler
    ../../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../../../../../../xmega/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group xmega/utils/bit_handling
    ../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
