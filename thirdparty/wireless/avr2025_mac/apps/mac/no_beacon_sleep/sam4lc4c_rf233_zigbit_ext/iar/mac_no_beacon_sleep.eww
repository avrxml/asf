<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mac_no_beacon_sleep_flash.ewp</path>
	</project>
</workspace>
