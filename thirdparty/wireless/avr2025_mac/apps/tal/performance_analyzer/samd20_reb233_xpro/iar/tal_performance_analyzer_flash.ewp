# IAR project tal_performance_analyzer_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ANTENNA_DIVERSITY=0; FFD; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0=true; ENABLE_TFA; SYSTICK_MODE; _DEBUG_=0; TC_ASYNC=true; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; __SAMD20J18__; SPI_CALLBACK_MODE=false; BOARD=SAMD20_XPLAINED_PRO; ENABLE_DEEP_SLEEP; TAL_TYPE=AT86RF233; USART_CALLBACK_MODE=false; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../source/mac/inc; ../../../../../../../../sam0/drivers/port; ../../../../../../addons/sio2host/uart; ../../../../../../../../sam0/utils/preprocessor; ../../../../../source/pal/common_sw_timer; ../../../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../../../common2/services/delay; ../../../../../source/resources/queue/inc; ../../../../../../../../sam0/utils; ../../../../../../services/trx_access; ../../../../../include; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/boards; ../..; ..; ../../../../../../services/common_hw_timer/sam0; ../../../../../../../../common/services/serial; ../../../../../../../../sam0/drivers/system; ../../../../../source/tfa/inc; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/at86rf233/inc; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../sam0/drivers/tc; ../../../../../../../../sam0/utils/cmsis/samd20/include/component; ../../../../../../services/common_hw_timer; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common2/services/delay/sam0; ../../../../../../../../sam0/utils/cmsis/samd20/include/pio; ../../../../../../../../common/boards; ../../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/utils/cmsis/samd20/include/instance; ../../../../../../../../sam0/drivers/sercom/usart; ../../inc; ../../../../../../../../sam0/drivers/extint; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tal_performance_analyzer_flash.bin
  ILINK.IlinkOutputFile: tal_performance_analyzer_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer
    ../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c init_state.c user_interface.c wait_for_event.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c peer_search_initiator.c performance_main.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/samd20_reb233_xpro
    ../: conf_trx_access.h conf_sio2host.h conf_board.h conf_hw_timer.h conf_sleepmgr.h conf_spi.h conf_clocks.h conf_extint.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/samd20_reb233_xpro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/inc
    ../../inc/: performance_main.h perf_msg_const.h perf_api.h app_peer_search.h user_interface.h app_range_mode.h app_frame_format.h perf_api_serial_handler.h app_config.h app_per_mode.h app_init.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal_rx.c tal_pib.c tal_slotted_csma.c tal_tx.c tal_irq_handler.c tal.c tal_ed.c tal_pwr_mgmt.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../source/tal/at86rf233/inc/: tal_pib.h tal_constants.h tal_internal.h tal_rx.h tal_slotted_csma.h tal_config.h tal_irq_handler.h at86rf233.h tal_tx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_msg_type_data_ind.h mac_api.h mac_config.h mac_msg_const.h mac.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: avr2025_mac.h mac_build_config.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/extint
    ../../../../../../../../sam0/drivers/extint/: extint.c extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/quick_start_polled
    ../../../../../../../../sam0/drivers/extint/quick_start_polled/: qs_extint_basic.h
  group sam0/drivers/extint/quick_start_callback
    ../../../../../../../../sam0/drivers/extint/quick_start_callback/: qs_extint_callback.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../../sam0/drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/tc
    ../../../../../../../../sam0/drivers/tc/: tc.c tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/quick_start
    ../../../../../../../../sam0/drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../../../../../sam0/drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../../../../../sam0/drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../../../../../sam0/drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../../sam0/utils/cmsis/samd20/include/: samd20g18.h samd20g16.h samd20j18.h samd20j14.h samd20e14.h samd20j15.h samd20g14.h samd20j17.h samd20g17.h samd20e16.h samd20e17.h samd20g15.h samd20.h samd20j16.h samd20e15.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd20/include/instance/: instance_tc2.h instance_sercom5.h instance_sercom2.h instance_rtc.h instance_tc4.h instance_sercom0.h instance_ac.h instance_tc7.h instance_tc1.h instance_tc3.h instance_sercom3.h instance_adc.h instance_wdt.h instance_sysctrl.h instance_sercom1.h instance_tc5.h instance_gclk.h instance_evsys.h instance_dac.h instance_sercom4.h instance_eic.h instance_pac1.h instance_pm.h instance_dsu.h instance_port.h instance_pac2.h instance_tc6.h instance_tc0.h instance_pac0.h instance_nvmctrl.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd20/include/pio/: pio_samd20g16.h pio_samd20j16.h pio_samd20g17.h pio_samd20g15.h pio_samd20e17.h pio_samd20e14.h pio_samd20j14.h pio_samd20e16.h pio_samd20j17.h pio_samd20g18.h pio_samd20g14.h pio_samd20e1f.h pio_samd20e15.h pio_samd20j15.h pio_samd20j18.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../../sam0/utils/cmsis/samd20/include/component/: component_pac.h component_rtc.h component_wdt.h component_tc.h component_port.h component_gclk.h component_dac.h component_dsu.h component_evsys.h component_nvmctrl.h component_pm.h component_sercom.h component_adc.h component_sysctrl.h component_ac.h component_eic.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: preprocessor.h mrecursion.h tpaste.h stringz.h mrepeat.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
