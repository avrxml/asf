<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tal_performance_analyzer_flash.ewp</path>
	</project>
</workspace>
