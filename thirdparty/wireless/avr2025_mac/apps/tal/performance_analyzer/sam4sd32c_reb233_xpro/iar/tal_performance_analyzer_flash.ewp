# IAR project tal_performance_analyzer_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ANTENNA_DIVERSITY=0; FFD; ENABLE_TFA; TAL_TYPE=AT86RF233; _DEBUG_=0; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; BOARD=SAM4S_XPLAINED_PRO; ENABLE_DEEP_SLEEP; DISABLE_TSTAMP_IRQ=1; ARM_MATH_CM4=true; __SAM4SD32C__; PAL_USE_SPI_TRX=1
  ICCARM.CCIncludePath2: ../../../../../../../../sam/boards/sam4s_xplained_pro; ../../../../../../../../common/services/serial/sam_uart; ../../../../../source/mac/inc; ../../../../../../../../common/services/spi/sam_spi; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../source/pal/common_sw_timer; ../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../source/resources/queue/inc; ../../../../../../services/trx_access; ../../../../../include; ../../../../../../addons/sio2host/uart; ../..; ../../../../../../../../common/services/serial; ../../../../../../../../common/services/ioport; ../../../../../source/tfa/inc; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/boards; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/at86rf233/inc; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../services/common_hw_timer/sam; ../../../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../../services/common_hw_timer; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../common/services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../common/services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../inc; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tal_performance_analyzer_flash.bin
  ILINK.IlinkOutputFile: tal_performance_analyzer_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer
    ../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c user_interface.c wait_for_event.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c performance_main.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/sam4sd32c_reb233_xpro
    ../: conf_trx_access.h conf_sio2host.h conf_uart_serial.h conf_perf_analyzer.h conf_clock.h conf_board.h conf_spi_master.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/sam4sd32c_reb233_xpro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/inc
    ../../inc/: performance_main.h perf_api.h perf_msg_const.h app_peer_search.h user_interface.h app_frame_format.h perf_api_serial_handler.h app_config.h app_per_mode.h app_range_mode.h app_init.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal_rx.c tal_pib.c tal_tx.c tal_irq_handler.c tal.c tal_ed.c tal_pwr_mgmt.c tal_slotted_csma.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../source/tal/at86rf233/inc/: tal_constants.h tal_internal.h tal_rx.h tal_slotted_csma.h tal_config.h tal_irq_handler.h at86rf233.h tal_pib.h tal_tx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal_generic.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac.h mac_api.h mac_msg_type_data_ind.h mac_config.h mac_msg_const.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: ieee_154g.h mac_build_config.h avr2025_mac.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/boards/sam4s_xplained_pro
    ../../../../../../../../sam/boards/sam4s_xplained_pro/: init.c sam4s_xplained_pro.h led.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s4a.h sam4s4c.h sam4s8c.h sam4sd32b.h sam4s16b.h sam4sa16b.h sam4s2c.h sam4sa16c.h sam4s2a.h system_sam4s.h sam4sd16c.h sam4s8b.h sam4s.h sam4sd16b.h sam4s4b.h sam4sd32c.h sam4s16c.h sam4s2b.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_tc.h component_smc.h component_gpbr.h component_cmcc.h component_rtc.h component_dacc.h component_ssc.h component_pio.h component_matrix.h component_efc.h component_rtt.h component_rstc.h component_uart.h component_chipid.h component_pwm.h component_pmc.h component_udp.h component_wdt.h component_supc.h component_crccu.h component_usart.h component_twi.h component_spi.h component_pdc.h component_acc.h component_hsmci.h component_adc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4sd16b.h pio_sam4s2a.h pio_sam4sa16c.h pio_sam4s16c.h pio_sam4s8b.h pio_sam4s4a.h pio_sam4s16b.h pio_sam4s4b.h pio_sam4s2b.h pio_sam4s8c.h pio_sam4sd32c.h pio_sam4s4c.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_cmcc.h instance_crccu.h instance_efc0.h instance_chipid.h instance_tc0.h instance_pmc.h instance_usart0.h instance_piob.h instance_twi0.h instance_hsmci.h instance_efc1.h instance_acc.h instance_spi.h instance_adc.h instance_ssc.h instance_tc1.h instance_pwm.h instance_udp.h instance_dacc.h instance_wdt.h instance_rtc.h instance_uart0.h instance_matrix.h instance_twi1.h instance_supc.h instance_rtt.h instance_usart1.h instance_gpbr.h instance_pioa.h instance_pioc.h instance_rstc.h instance_uart1.h instance_smc.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../../../common/services/clock/sam4s/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
