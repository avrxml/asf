# IAR project tal_performance_analyzer_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ANTENNA_DIVERSITY=0; FFD; ENABLE_TFA; TAL_TYPE=AT86RF233; _DEBUG_=0; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; __SAM4E16E__; BOARD=SAM4E_XPLAINED_PRO; ENABLE_DEEP_SLEEP; DISABLE_TSTAMP_IRQ=1; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../../../../../source/mac/inc; ../../../../../../../../common/services/spi/sam_spi; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/boards/sam4e_xplained_pro; ../../../../../../../../sam/drivers/pio; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../../services/trx_access; ../../../../../include; ../../../../../../addons/sio2host/uart; ../..; ../../../../../../../../sam/utils/fpu; ../../../../../../../../common/services/serial; ../../../../../../../../common/services/ioport; ../../../../../source/tfa/inc; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../../sam/boards; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/at86rf233/inc; ../../../../../../../../common/services/clock; ../../../../../../services/common_hw_timer/sam; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../services/common_hw_timer; ../../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../common/services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ..; ../../inc; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tal_performance_analyzer_flash.bin
  ILINK.IlinkOutputFile: tal_performance_analyzer_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer
    ../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c user_interface.c wait_for_event.c per_mode_receptor.c performance_main.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/sam4e16e_sam4e_xpro
    ../: conf_trx_access.h conf_sio2host.h conf_uart_serial.h conf_board.h conf_spi_master.h conf_clock.h conf_perf_analyzer.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/sam4e16e_sam4e_xpro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/inc
    ../../inc/: app_range_mode.h performance_main.h perf_api.h perf_msg_const.h app_peer_search.h user_interface.h app_frame_format.h perf_api_serial_handler.h app_config.h app_per_mode.h app_init.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal_rx.c tal_pib.c tal_tx.c tal_irq_handler.c tal.c tal_ed.c tal_pwr_mgmt.c tal_slotted_csma.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../source/tal/at86rf233/inc/: tal_pib.h tal_constants.h tal_internal.h tal_rx.h tal_slotted_csma.h tal_config.h tal_tx.h tal_irq_handler.h at86rf233.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_config.h mac_api.h mac_msg_const.h mac_msg_type_data_ind.h mac.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: ieee_154g.h mac_build_config.h avr2025_mac.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../../../../sam/boards/sam4e_xplained_pro/: init.c led.h sam4e_xplained_pro.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e8c.h sam4e8e.h sam4e8cb.h sam4e.h sam4e16cb.h sam4e16c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../../sam/utils/cmsis/sam4e/include/component/: rstc.h supc.h dacc.h tc.h pwm.h afec.h cmcc.h usart.h rtc.h udp.h acc.h pio.h efc.h pmc.h hsmci.h can.h twi.h aes.h spi.h chipid.h matrix.h wdt.h smc.h dmac.h rswdt.h pdc.h gpbr.h gmac.h rtt.h uart.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4e/include/instance/: twi1.h piob.h pwm.h udp.h can0.h chipid.h tc2.h usart0.h pmc.h dacc.h dmac.h pioc.h piod.h gpbr.h pioa.h tc0.h wdt.h hsmci.h gmac.h rtc.h afec1.h uart0.h rstc.h aes.h efc.h acc.h rtt.h supc.h twi0.h afec0.h uart1.h pioe.h spi.h can1.h rswdt.h cmcc.h smc.h tc1.h matrix.h usart1.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16cb.h sam4e8e.h sam4e8cb.h sam4e16e.h sam4e16c.h sam4e8c.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4e
    ../../../../../../../../common/services/clock/sam4e/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
