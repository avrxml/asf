# IAR project tal_performance_analyzer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: FFD; ENABLE_TFA; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; BOARD=ATMEGARFX_RCB; TAL_TYPE=ATMEGARFR2
  ICCAVR.newCCIncludePaths: ../../../../../source/mac/inc; ../../../../../../../../mega/utils/preprocessor; ../../../../../../../../mega/utils; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../../addons/sio2host/usb_ftdi; ../..; ../../../../../../../../common/services/ioport; ../../../../../source/tfa/inc; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../include; ../../../../../source/tal/atmegarfr2/inc; ../../../../../../../../mega/boards/atmegarfx_rcb; ../../../../../../../../mega/drivers/cpu; ../../../../../../../../common/services/clock; ../../../../../../../../mega/boards; ..; ../../../../../../services/common_hw_timer/mega; ../../../../../../services/common_hw_timer; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/delay; ../../../../../../../../common/boards; ../../inc; ../../../../../../services/mega/drivers/tc; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; ENABLE_TFA; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; BOARD=ATMEGARFX_RCB; TAL_TYPE=ATMEGARFR2
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega
    ../../../../../../services/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega/lib
    ../../../../../../services/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/services/mega/drivers/tc
    ../../../../../../services/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../source/tal/atmegarfr2/src/: tal_init.c tal_ed.c tal_pib.c tal_irq_handler.c tal.c tal_tx.c tal_pwr_mgmt.c tal_slotted_csma.c tal_rx_enable.c tal_rx.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/inc
    ../../../../../source/tal/atmegarfr2/inc/: tal_slotted_csma.h atmega256rfr2.h tal_internal.h tal_irq_handler.h tal_tx.h tal_pib.h tal_config.h tal_constants.h tal_rx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal.h tal_timer_config.h tal_types.h tal_generic.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tfa/atmegarfr2/src
    ../../../../../source/tfa/atmegarfr2/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_msg_type_data_ind.h mac.h mac_api.h mac_msg_types.h mac_config.h mac_msg_const.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer
    ../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c wait_for_event.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c user_interface.c performance_main.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/inc
    ../../inc/: app_frame_format.h perf_api_serial_handler.h performance_main.h app_config.h app_per_mode.h user_interface.h app_init.h perf_msg_const.h app_peer_search.h app_range_mode.h perf_api.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/atmega256rfr2_rcb
    ../: conf_sio2host.h conf_clock.h conf_board.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/atmega256rfr2_rcb/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: mac_build_config.h return_val.h tal_build_config.h ieee_const.h avr2025_mac.h stack_config.h
  group thirdparty/wireless/addons/sio2host/usb_ftdi
    ../../../../../../addons/sio2host/usb_ftdi/: sio2host.c sio2host.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../../common/services/ioport/mega/: ioport.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group mega/boards/atmegarfx_rcb
    ../../../../../../../../mega/boards/atmegarfx_rcb/: init.c helper.c atmegarfx_rcb.h led.h helper.h
  group mega/utils
    ../../../../../../../../mega/utils/: progmem.h status_codes.h assembler.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../../mega/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../../mega/utils/assembler/: iar.h
  group mega/drivers/cpu
    ../../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
