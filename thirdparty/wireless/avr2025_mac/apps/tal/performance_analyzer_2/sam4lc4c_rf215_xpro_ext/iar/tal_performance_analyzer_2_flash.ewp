# IAR project tal_performance_analyzer_2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ANTENNA_DIVERSITY=0; FFD; SPECIFIC_TAL_CONFIG; BOARD=SAM4L_XPLAINED_PRO; ENABLE_TFA; _DEBUG_=0; __SAM4LC4C__; HIGHEST_STACK_LAYER=TAL; UDD_ENABLE; MULTI_TRX_SUPPORT; TAL_TYPE=AT86RF215; SUPPORT_FSK; SUPPORT_OQPSK; ENABLE_DEEP_SLEEP; SUPPORT_LEGACY_OQPSK; PAL_USE_SPI_TRX=1; SUPPORT_OFDM; ARM_MATH_CM4=true; ENABLE_LARGE_BUFFER; RF215V1
  ICCARM.CCIncludePath2: ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../../common/services/serial/sam_uart; ../../../../../source/mac/inc; ../../../../../../../../common/services/spi/sam_spi; ../../../../../../../../sam/drivers/usbc; ../../../../../../../../sam/utils/preprocessor; ../../../../../source/pal/common_sw_timer; ..; ../../../../../source/resources/queue/inc; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../services/trx_access; ../../../../../include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../source/pal; ../../../../../../../../common/services/serial; ../../../../../source/tfa/inc; ../../../../../../addons/sio2host/usb; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/eic; ../../../../../../../../sam/boards; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../addons/sio2ncp/uart; ../../../../../../../../common/services/usb/class/cdc; ../../../../../source/tal/at86rf215/inc; ../../../../../../../../common/services/clock; ../../../../../../services/common_hw_timer/sam; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/services/usb; ../../../../../../../../sam/drivers/gpio; ../../../../../source/tal/inc; ../../inc; ../../../../../../../../common/services/delay; ../../../../../../../../sam/utils; ../../../../../../../../common/services/usb/udc; ../../../../../../../../sam/drivers/tc; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../common/boards; ../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/bpm; ../../../../../../../../common/services/spi; ../..; ../../../../../../services/common_hw_timer; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tal_performance_analyzer_2_flash.bin
  ILINK.IlinkOutputFile: tal_performance_analyzer_2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access_2.c trx_access_2.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf215/src
    ../../../../../source/tal/at86rf215/src/: tal_rx_enable.c tal_phy_cfg.c tal_ftn.c tal_ed.c tal_rand.c tal_mode_switch.c tal_pib.c tal_fe.c tal_init.c tal_auto_ack.c tal_pwr_mgmt.c tal_auto_tx.c tal_auto_csma.c tal_auto_rx.c tal.c tal_irq_handler.c tal_4g_utils.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf215/inc
    ../../../../../source/tal/at86rf215/inc/: tal_fe_fsk_params.h tal_rf215.h tal_pib.h at86rf215.h tal_config.h tal_internal.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper_2.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_helper_2.h tal_generic.h tal_multi_trx.h tal.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf215/src
    ../../../../../source/tfa/at86rf215/src/: tfa.c tfa_batmon.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_config.h mac_api.h mac_msg_type_data_ind.h mac_msg_const.h mac.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer_2
    ../../: main.c conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer_2/src
    ../../src/: perf_api_serial_handler.c user_interface.c wait_for_event.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c performance_main.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer_2/sam4lc4c_rf215_xpro_ext
    ../: conf_trx_access.h conf_sio2host.h conf_sio2ncp.h conf_uart_serial.h conf_clock.h conf_hw_timer.h conf_board.h conf_usb.h conf_spi_master.h conf_sleepmgr.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer_2/sam4lc4c_rf215_xpro_ext/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer_2/inc
    ../../inc/: app_range_mode.h specific_tal_config.h performance_main.h perf_api.h perf_msg_const.h app_peer_search.h user_interface.h app_frame_format.h perf_api_serial_handler.h app_config.h app_per_mode.h app_init.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: ieee_154g.h avr2025_mac.h mac_build_config.h return_val.h ieee_const.h tal_build_config.h stack_config.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../../../addons/sio2ncp/uart/: sio2ncp.c sio2ncp.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group sam/drivers/eic
    ../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/gpio
    ../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/usbc
    ../../../../../../../../sam/drivers/usbc/: usbc_device.c usbc_otg.h usbc_device.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls4b.h sam4l.h sam4lc8b.h sam4lc4c.h sam4lc4a.h sam4lc2a.h sam4lc2c.h sam4ls4a.h sam4ls2c.h sam4ls8c.h sam4lc8c.h sam4ls4c.h sam4lc4b.h sam4lc2b.h sam4ls8a.h sam4ls2a.h sam4ls2b.h sam4ls8b.h sam4lc8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_tc1.h instance_freqm.h instance_eic.h instance_pm.h instance_chipid.h instance_usart2.h instance_iisc.h instance_trng.h instance_smap.h instance_acifc.h instance_aesa.h instance_catb.h instance_parc.h instance_wdt.h instance_spi.h instance_twim0.h instance_ast.h instance_usart0.h instance_crccu.h instance_twis0.h instance_usart3.h instance_bscif.h instance_twim2.h instance_scif.h instance_gpio.h instance_adcife.h instance_lcdca.h instance_gloc.h instance_twis1.h instance_pevc.h instance_picouart.h instance_bpm.h instance_twim1.h instance_abdacb.h instance_usart1.h instance_hcache.h instance_tc0.h instance_hflashc.h instance_twim3.h instance_dacc.h instance_pdca.h instance_hmatrix.h instance_usbc.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc2b.h pio_sam4lc8c.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc4a.h pio_sam4lc4c.h pio_sam4ls8a.h pio_sam4ls4b.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4lc4b.h pio_sam4lc2c.h pio_sam4lc2a.h pio_sam4ls8b.h pio_sam4ls2b.h pio_sam4ls2a.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_flashcalw.h component_freqm.h component_parc.h component_usbc.h component_adcife.h component_lcdca.h component_iisc.h component_gloc.h component_twim.h component_crccu.h component_ast.h component_hmatrixb.h component_bscif.h component_bpm.h component_eic.h component_twis.h component_spi.h component_usart.h component_trng.h component_hcache.h component_gpio.h component_tc.h component_scif.h component_pdca.h component_picouart.h component_pm.h component_dacc.h component_smap.h component_pevc.h component_aesa.h component_catb.h component_abdacb.h component_acifc.h component_chipid.h component_wdt.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h dfll.h genclk.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c osc.c pll.c dfll.h osc.h genclk.h sysclk.h pll.h
  group common/services/usb
    ../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c udc.h udd.h udi.h udc_desc.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
