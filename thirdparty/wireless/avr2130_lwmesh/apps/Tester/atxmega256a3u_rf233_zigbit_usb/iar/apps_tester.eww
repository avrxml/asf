<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_tester.ewp</path>
	</project>
</workspace>
