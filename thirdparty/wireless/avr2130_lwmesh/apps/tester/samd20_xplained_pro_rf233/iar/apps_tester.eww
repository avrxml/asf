<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_tester_flash.ewp</path>
	</project>
</workspace>
