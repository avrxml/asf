<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_wsndemo_flash.ewp</path>
	</project>
</workspace>
