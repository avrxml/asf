# IAR project apps_wsndemo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: SAL_TYPE=ATMEGARF_SAL; BOARD=ATMEGA256RFR2_XPLAINED_PRO; PHY_ATMEGARFR2
  ICCAVR.newCCIncludePaths: ../../../../../../../mega/utils/preprocessor; ../../../../../../../mega/utils; ../../../../../services/sal/inc; ../../../../../../../mega/drivers/macsc; ../../../../../../../mega/boards/atmega256rfr2_xplained_pro; ../../../../../../../common/services/serial; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../services/sleep_mgr; ../../../../../../../mega/drivers/cpu; ../../../../source/nwk/inc; ../../../../../../../common/services/clock; ../../../../../../../mega/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../services/common_hw_timer/mega; ../../../../../../../mega/drivers/sleep; ../../../../source/sys/inc; ../../../../../../../common/services/delay; ../../../../../services/common_hw_timer; ../../../../../../../mega/drivers/usart; ../../../../../addons/sio2host/uart; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial/megarf_usart; ../..; ../../../../source/phy/atmegarfr2/inc; ../../../../../../../common/boards; ..; ../../../../../../../common/services/ioport; ../../../../../services/mega/drivers/tc; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; SAL_TYPE=ATMEGARF_SAL; BOARD=ATMEGA256RFR2_XPLAINED_PRO; PHY_ATMEGARFR2
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega
    ../../../../../services/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega/lib
    ../../../../../services/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/megarf
    ../../../../../services/sleep_mgr/megarf/: sleep_mgr.c
  group thirdparty/wireless/services/mega/drivers/tc
    ../../../../../services/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/services/sal/atmegarf_sal/src
    ../../../../../services/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkFrame.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkTx.h nwkCommand.h nwkDataReq.h nwk.h nwkSecurity.h nwkRx.h nwkFrame.h nwkRoute.h nwkGroup.h nwkRouteDiscovery.h
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sys.c sysEncrypt.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysEncrypt.h sysConfig.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/atmegarfr2/src
    ../../../../source/phy/atmegarfr2/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/atmegarfr2/inc
    ../../../../source/phy/atmegarfr2/inc/: phy.h atmegarfr2.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: wsndemo.c commands.c main.c config.h commands.h wsndemo.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/atmega256rfr2_xplained_pro
    ../: conf_usart_serial.h conf_trx_access.h conf_sio2host.h conf_clock.h conf_hw_timer.h conf_board.h conf_sleepmgr.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group mega/drivers/macsc
    ../../../../../../../mega/drivers/macsc/: macsc_megarf.c macsc_megarf.h
  group mega/drivers/usart
    ../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/sleep
    ../../../../../../../mega/drivers/sleep/: sleep_megarf.h sleep.h
  group mega/drivers/cpu
    ../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/utils
    ../../../../../../../mega/utils/: progmem.h status_codes.h assembler.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../mega/utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../mega/utils/assembler/: iar.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/mega
    ../../../../../../../common/services/sleepmgr/mega/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../common/services/ioport/mega/: ioport.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../common/boards/: board.h
