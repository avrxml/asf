# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; RTC_COUNT_ASYNC=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAML21J18A__; SPI_CALLBACK_MODE=false; SAL_TYPE=AT86RF2xx; PHY_AT86RF212B; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ..; ../../../../../../../sam0/utils/preprocessor; ../../../../source/phy/at86rf212b/inc; ../../../../../services/sal/inc; ../../../../../../../common2/services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../services/trx_access; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../services/common_hw_timer/sam0; ../../../../../../../common/services/serial; ../../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../../sam0/drivers/rtc; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/rtc/rtc_sam_l_c; ../../../../../../../sam0/drivers/extint; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/drivers/tc; ../../../../../../../sam0/utils/header_files; ../../../../../services/common_hw_timer; ../../../../../../../sam0/boards/saml21_xplained_pro; ../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../addons/sio2host/uart; ../../../../../../../common2/services/delay/sam0; ../..; ../../../../../../../sam0/utils/cmsis/saml21/include; ../../../../source/nwk/inc; ../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../services/sleep_mgr; ../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../source/sys/inc; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam0
    ../../../../../services/sleep_mgr/sam0/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sys.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysConfig.h sysEncrypt.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkFrame.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkCommand.h nwkRx.h nwk.h nwkRoute.h nwkGroup.h nwkRouteDiscovery.h nwkDataReq.h nwkTx.h nwkSecurity.h nwkFrame.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/src
    ../../../../source/phy/at86rf212b/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/inc
    ../../../../source/phy/at86rf212b/inc/: at86rf212b.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: wsndemo.c main.c commands.c config.h wsndemo.h commands.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/saml21_xplained_pro_rf212b
    ../: conf_trx_access.h conf_sio2host.h conf_rtc.h conf_board.h conf_sleepmgr.h conf_extint.h conf_spi.h conf_clocks.h conf_hw_timer.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/saml21_xplained_pro_rf212b/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../sam0/utils/cmsis/saml21/include/: saml21.h saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../sam0/utils/cmsis/saml21/include/component/: evsys.h osc32kctrl.h rtc_100.h tc_100.h gclk_100.h dsu.h supc_100.h port.h aes.h usb.h mclk_100.h wdt.h trng.h mtb.h pac_100.h ccl.h opamp.h nvmctrl_301.h ac.h dmac.h oscctrl.h rstc_100.h dac.h adc_100.h sercom.h pm_100.h tal.h eic_100.h tcc_200.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include/instance/: tcc1_200.h sercom1.h mtb.h ac.h opamp.h wdt.h tc0_100.h osc32kctrl.h aes.h port.h sercom5.h eic_100.h tc4_100.h usb.h tal.h dmac.h rtc_100.h dac.h oscctrl.h tc3_100.h rstc_100.h dsu.h adc_100.h mclk_100.h pm_100.h tc1_100.h gclk_100.h tcc0_200.h sercom4.h supc_100.h sercom2.h tcc2_200.h sercom0.h tc2_100.h ccl.h nvmctrl_301.h pac_100.h evsys.h trng.h sercom3.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../../../sam0/drivers/rtc/rtc_sam_l_c/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
