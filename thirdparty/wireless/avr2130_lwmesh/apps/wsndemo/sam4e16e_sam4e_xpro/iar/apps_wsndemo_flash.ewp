# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_XPLAINED_PRO; __SAM4E16E__; SAL_TYPE=AT86RF2xx; ARM_MATH_CM4=true; PHY_AT86RF233
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/boards/sam4e_xplained_pro; ../../../../../../../sam/drivers/pmc; ../../../../../services/sal/inc; ../../../../../services/trx_access; ../../../../../../../sam/utils/fpu; ../../../../../../../common/services/serial; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../sam/drivers/supc; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../services/sleep_mgr; ../../../../source/phy/at86rf233/inc; ../../../../source/nwk/inc; ../../../../../../../common/services/clock; ../../../../../services/common_hw_timer/sam; ../../../../../../../sam/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../source/sys/inc; ../../../../../services/common_hw_timer; ../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../addons/sio2host/uart; ../../../../../../../common/services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/drivers/rtt; ../../../../../../../sam/utils; ../..; ..; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/tc; ../../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam
    ../../../../../services/sleep_mgr/sam/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sys.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysConfig.h sysEncrypt.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkFrame.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkCommand.h nwkRx.h nwkRoute.h nwkGroup.h nwkDataReq.h nwkTx.h nwk.h nwkSecurity.h nwkFrame.h nwkRouteDiscovery.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/src
    ../../../../source/phy/at86rf233/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc
    ../../../../source/phy/at86rf233/inc/: at86rf233.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: wsndemo.c main.c commands.c config.h wsndemo.h commands.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4e16e_sam4e_xpro
    ../: conf_trx_access.h conf_sio2host.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4e16e_sam4e_xpro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e8c.h sam4e16cb.h sam4e8e.h sam4e.h sam4e8cb.h sam4e16e.h sam4e16c.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../sam/utils/cmsis/sam4e/include/component/: matrix.h aes.h pdc.h rtt.h gpbr.h gmac.h pio.h rswdt.h efc.h uart.h tc.h smc.h afec.h wdt.h twi.h hsmci.h pmc.h udp.h usart.h supc.h dmac.h rtc.h can.h acc.h rstc.h chipid.h cmcc.h spi.h pwm.h dacc.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16c.h sam4e8c.h sam4e8e.h sam4e8cb.h sam4e16cb.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../sam/utils/cmsis/sam4e/include/instance/: udp.h uart0.h pmc.h usart1.h aes.h afec0.h can0.h afec1.h piod.h matrix.h piob.h can1.h efc.h chipid.h twi0.h dmac.h tc0.h rtc.h pwm.h tc2.h wdt.h rtt.h gpbr.h gmac.h hsmci.h supc.h twi1.h tc1.h acc.h rstc.h usart0.h spi.h uart1.h cmcc.h rswdt.h smc.h dacc.h pioa.h pioe.h pioc.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rtt
    ../../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../../../sam/boards/sam4e_xplained_pro/: init.c led.h sam4e_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../../../common/services/clock/sam4e/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
