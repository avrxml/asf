<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_wsndemo.ewp</path>
	</project>
</workspace>
