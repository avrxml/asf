# IAR project apps_wsndemo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: BOARD=XMEGA_RF212B_ZIGBIT; SAL_TYPE=ATXMEGA_SAL; PHY_AT86RF212B; IOPORT_XMEGA_COMPAT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../xmega/drivers/pmic; ../../../../../../../common/services/spi/xmega_spi; ../../../../../../../xmega/drivers/tc; ../../../../../../../xmega/utils; ../../../../source/phy/at86rf212b/inc; ../../../../../services/sal/inc; ../../../../../services/trx_access; ..; ../../../../../../../common/services/gpio; ../../../../../../../common/services/ioport; ../../../../../addons/sio2host/usb; ../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../xmega/drivers/nvm; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../services/sleep_mgr; ../../../../../../../common/services/usb/class/cdc; ../../../../source/nwk/inc; ../../../../../../../common/services/clock; ../../../../../../../common/services/usb/udc; ../../../../../../../common/services/usb; ../../../../../services/common_hw_timer; ../../../../../../../xmega/boards; ../../../../../../../xmega/boards/xmega_rf212b_zigbit; ../../../../../services/common_hw_timer/xmega; ../../../../../../../common/services/delay; ../../../../source/sys/inc; ../../../../../../../xmega/drivers/usb; ../../../../../../../common/services/spi; ../..; ../../../../../../../common/boards; ../../../../../../../xmega/drivers/spi; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_RF212B_ZIGBIT; SAL_TYPE=ATXMEGA_SAL; PHY_AT86RF212B; IOPORT_XMEGA_COMPAT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/xmega_a3u
    ../../../../../services/sleep_mgr/xmega_a3u/: sleep_mgr.c
  group thirdparty/wireless/services/sal/atxmega_sal/src
    ../../../../../services/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sys.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysEncrypt.h sysConfig.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkFrame.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkCommand.h nwkRx.h nwkRoute.h nwkGroup.h nwkDataReq.h nwkTx.h nwk.h nwkSecurity.h nwkFrame.h nwkRouteDiscovery.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/src
    ../../../../source/phy/at86rf212b/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/inc
    ../../../../source/phy/at86rf212b/inc/: at86rf212b.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: wsndemo.c commands.c main.c config.h commands.h wsndemo.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/atxmega256a3u_rf212b_zigbit_usb
    ../: conf_trx_access.h conf_sio2host.h conf_clock.h conf_board.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/atxmega256a3u_rf212b_zigbit_usb/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group xmega/drivers/tc
    ../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/spi
    ../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_rf212b_zigbit
    ../../../../../../../xmega/boards/xmega_rf212b_zigbit/: init.c xmega_rf212b_zigbit.h led.h
  group xmega/utils
    ../../../../../../../xmega/utils/: assembler.h compiler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../../common/services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../../common/services/usb/udc/: udc.c udd.h udc.h udi.h udc_desc.h
  group common/services/usb/class/cdc
    ../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../common/boards/: board.h
