# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; RTC_COUNT_ASYNC=true; BOARD=SAMR21_XPLAINED_PRO; SYSTICK_MODE; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; __SAMR21G18A__; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=false; SAL_TYPE=AT86RF2xx; PHY_AT86RF233
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ..; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/utils/cmsis/samr21/source; ../../../../../services/sal/inc; ../../../../../../../common2/services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../services/trx_access; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../source/nwk/inc; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../services/common_hw_timer/sam0; ../../../../../../../common/services/serial; ../../../../../../../sam0/drivers/rtc; ../../../../../../../common/utils; ../../../../../services/sleep_mgr; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/tc; ../../../../source/sys/inc; ../../../../../services/common_hw_timer; ../../../../../addons/sio2host/uart; ../../../../../../../common2/services/delay/sam0; ../../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../../sam0/utils/cmsis/samr21/include; ../..; ../../../../source/phy/at86rf233/inc; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/drivers/extint; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam0
    ../../../../../services/sleep_mgr/sam0/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sys.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysConfig.h sysEncrypt.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkFrame.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkCommand.h nwkRx.h nwk.h nwkRoute.h nwkGroup.h nwkRouteDiscovery.h nwkDataReq.h nwkTx.h nwkSecurity.h nwkFrame.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/src
    ../../../../source/phy/at86rf233/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc
    ../../../../source/phy/at86rf233/inc/: phy.h at86rf233.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: wsndemo.c main.c commands.c config.h wsndemo.h commands.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/samr21_xplained_pro
    ../: conf_trx_access.h conf_board.h conf_sleepmgr.h conf_sio2host.h conf_extint.h conf_spi.h conf_clocks.h conf_hw_timer.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/samr21_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint.c extint_callback.c extint_callback.h extint.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc.c tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../../../../sam0/drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start
    ../../../../../../../sam0/drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../../../../sam0/drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../../../../sam0/drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_count_interrupt.c rtc_count.c rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/quick_start_count_callback
    ../../../../../../../sam0/drivers/rtc/quick_start_count_callback/: qs_rtc_count_callback.h
  group sam0/drivers/rtc/quick_start_count
    ../../../../../../../sam0/drivers/rtc/quick_start_count/: qs_rtc_count_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../sam0/utils/cmsis/samr21/include/: samr21g18a.h samr21e18a.h samr21e17a.h samr21e16a.h samr21g17a.h samr21.h samr21g16a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../sam0/utils/cmsis/samr21/include/instance/: rtc.h tc4.h dsu.h ac.h eic.h pac2.h tc7.h i2s.h pac0.h usb.h pm.h tc5.h port.h sercom5.h sercom2.h tcc1.h sercom4.h adc.h wdt.h sercom0.h mtb.h sercom3.h tcc0.h dac.h tc6.h sysctrl.h gclk.h nvmctrl.h tcc2.h sercom1.h tc3.h rfctrl.h pac1.h evsys.h dmac.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../sam0/utils/cmsis/samr21/include/component/: adc.h port.h sysctrl.h usb.h gclk.h dsu.h sercom.h tcc.h dmac.h evsys.h mtb.h pm.h rtc.h i2s.h eic.h nvmctrl.h wdt.h tc.h rfctrl.h pac.h ac.h dac.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21g18a.h samr21e16a.h samr21g16a.h samr21g17a.h samr21e17a.h samr21e18a.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
