# IAR project apps_peer2peer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: SAL_TYPE=ATMEGARF_SAL; PHY_ATMEGARFA1; BOARD=ATMEGARFX_RCB
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../../../mega/utils/preprocessor; ../../../../../../../mega/utils; ../../../../../services/sal/inc; ../..; ../../../../../../../common/services/serial; ..; ../../../../source/phy/atmegarfa1/inc; ../../../../../../../common/utils; ../../../../../../../mega/boards/atmegarfx_rcb; ../../../../../../../mega/drivers/cpu; ../../../../source/nwk/inc; ../../../../../../../common/services/clock; ../../../../../../../mega/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../services/common_hw_timer/mega; ../../../../source/sys/inc; ../../../../../../../common/services/delay; ../../../../../services/common_hw_timer; ../../../../../../../mega/drivers/usart; ../../../../../addons/sio2host/uart; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial/megarf_usart; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../services/mega/drivers/tc; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: SAL_TYPE=ATMEGARF_SAL; PHY_ATMEGARFA1; BOARD=ATMEGARFX_RCB
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; SAL_TYPE=ATMEGARF_SAL; PHY_ATMEGARFA1; BOARD=ATMEGARFX_RCB
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega
    ../../../../../services/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega/lib
    ../../../../../services/common_hw_timer/mega/lib/: megarfa1_lib_hw_timer.r90
  group thirdparty/wireless/services/mega/drivers/tc
    ../../../../../services/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/services/sal/atmegarf_sal/src
    ../../../../../services/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sys.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysEncrypt.h sysConfig.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkFrame.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkCommand.h nwkTx.h nwkDataReq.h nwk.h nwkSecurity.h nwkRx.h nwkRoute.h nwkFrame.h nwkGroup.h nwkRouteDiscovery.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/atmegarfa1/src
    ../../../../source/phy/atmegarfa1/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/atmegarfa1/inc
    ../../../../source/phy/atmegarfa1/inc/: atmegarfa1.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer
    ../../: Peer2Peer.c conf_trx_access.h config.h
  group thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/atmega128rfa1_rcb
    ../: conf_sio2host.h conf_clock.h conf_hw_timer.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/atmega128rfa1_rcb/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group mega/boards/atmegarfx_rcb
    ../../../../../../../mega/boards/atmegarfx_rcb/: init.c helper.c atmegarfx_rcb.h led.h helper.h
  group mega/drivers/usart
    ../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../mega/utils/: status_codes.h progmem.h assembler.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../mega/utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../mega/utils/assembler/: iar.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
