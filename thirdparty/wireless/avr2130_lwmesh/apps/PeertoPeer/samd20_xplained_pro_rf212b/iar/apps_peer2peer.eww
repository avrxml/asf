<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_peer2peer_flash.ewp</path>
	</project>
</workspace>
