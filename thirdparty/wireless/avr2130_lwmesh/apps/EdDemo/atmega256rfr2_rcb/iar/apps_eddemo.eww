<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_eddemo.ewp</path>
	</project>
</workspace>
