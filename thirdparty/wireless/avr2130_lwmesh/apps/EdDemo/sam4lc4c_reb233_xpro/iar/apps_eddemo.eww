<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_eddemo_flash.ewp</path>
	</project>
</workspace>
