# IAR project avr2130_lwmesh_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: SAL_TYPE=ATXMEGA_SAL; _ASSERT_ENABLE_; PHY_AT86RF231; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/usb/class/cdc/device; ../../../../../../xmega/drivers/pmic; ../../../../../../common/services/spi/xmega_spi; ../../../../../../xmega/drivers/tc; ../../../../../../xmega/utils; ../../../../../../common/services/usb/udc; ../../../../services/sal/inc; ../../../../services/trx_access; ../../../../services/common_hw_timer/xmega; ../../../../../../common/services/ioport; ..; ../../../../../../common/utils/stdio/stdio_usb; ../../../../../../xmega/drivers/nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../source/nwk/inc; ../../../../../../common/services/clock; ../../../source/phy/at86rf231/inc; ../../../source/sys/inc; ../../../../../../common/services/usb; ../../../../services/common_hw_timer; ../../../../../../xmega/boards; ../..; ../../../../../../common/services/gpio; ../../../../../../common/services/delay; ../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../xmega/drivers/usb; ../../../../../../common/services/spi; ../../../../../../common/boards; ../../../../../../xmega/drivers/spi; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/drivers/sleep; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; SAL_TYPE=ATXMEGA_SAL; _ASSERT_ENABLE_; PHY_AT86RF231; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group thirdparty/wireless/services/common_hw_timer
    ../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/atxmega_sal/src
    ../../../../services/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../services/sal/inc/: sal_types.h sal.h sal_generic.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../source/nwk/src/: nwkGroup.c nwkSecurity.c nwk.c nwkRoute.c nwkRouteDiscovery.c nwkRx.c nwkFrame.c nwkDataReq.c nwkTx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../source/nwk/inc/: nwkFrame.h nwkRouteDiscovery.h nwk.h nwkGroup.h nwkRx.h nwkDataReq.h nwkSecurity.h nwkTx.h nwkRoute.h nwkCommand.h
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../source/sys/inc/: sysEncrypt.h sys.h sysConfig.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf231/src
    ../../../source/phy/at86rf231/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf231/inc
    ../../../source/phy/at86rf231/inc/: at86rf231.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/unit_tests
    ../../: unit_tests.c unit_tests.h config.h conf_trx_access.h
  group thirdparty/wireless/avr2130_lwmesh/unit_tests/xmega_a3bu_xplained_rz600rf231
    ../: conf_clock.h conf_board.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_test.h conf_hw_timer.h
  group thirdparty/wireless/avr2130_lwmesh/unit_tests/xmega_a3bu_xplained_rz600rf231/iar
    ./: asf.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udi.h udc.h udd.h udc_desc.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/drivers/spi
    ../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usb
    ../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/tc
    ../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/utils
    ../../../../../../xmega/utils/: assembler.h progmem.h status_codes.h compiler.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
