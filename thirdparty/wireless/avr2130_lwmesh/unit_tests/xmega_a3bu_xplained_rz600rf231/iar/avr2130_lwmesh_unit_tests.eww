<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr2130_lwmesh_unit_tests.ewp</path>
	</project>
</workspace>
