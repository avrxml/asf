<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_bridge_example.ewp</path>
	</project>
</workspace>
