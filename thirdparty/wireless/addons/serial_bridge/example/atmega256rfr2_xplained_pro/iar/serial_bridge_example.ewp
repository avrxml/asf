# IAR project serial_bridge_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../common/services/gpio; ../../../../../../../common/services/delay; ../../../../../../../mega/drivers/cpu; ../../../../../../../mega/utils; ../../../../../../../common/services/clock; ../../../../../../../mega/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/boards; ../../..; ../../../../../../../common/services/ioport; ../../../../../../../common/services/serial/megarf_usart; ../../../../../../../mega/boards/atmega256rfr2_xplained_pro; ..; ../../../../../../../common/utils; ../../../../../../../mega/drivers/usart; ../../../../sio2host/uart; ../../../../sio2ncp/uart; ../../../../../../../common/services/serial; ../../../../../../../mega/utils/preprocessor; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/drivers/usart
    ../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../mega/utils/: status_codes.h progmem.h assembler.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../mega/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../mega/utils/assembler/: iar.h
  group thirdparty/wireless/addons/serial_bridge
    ../../../: serial_bridge.c serial_bridge.h
  group thirdparty/wireless/addons/serial_bridge/example
    ../../: main.c
  group thirdparty/wireless/addons/serial_bridge/example/atmega256rfr2_xplained_pro
    ../: conf_sio2host.h conf_clock.h conf_board.h conf_sio2ncp.h conf_usart_serial.h
  group thirdparty/wireless/addons/serial_bridge/example/atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../sio2host/uart/: sio2host.c sio2host.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../sio2ncp/uart/: sio2ncp.c sio2ncp.h
