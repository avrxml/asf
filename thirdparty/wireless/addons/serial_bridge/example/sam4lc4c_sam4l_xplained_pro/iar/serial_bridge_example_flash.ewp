# IAR project serial_bridge_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC4C__; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..; ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../common/services/serial; ../../..; ../../../../../../../common/utils; ../../../../sio2ncp/uart; ../../../../../../../sam/drivers/wdt; ../../../../../../../common/services/clock; ../../../../../../../sam/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../sio2host/uart; ../../../../../../../common/services/delay; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/drivers/flashcalw; ../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4LC4C__; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial_bridge_example_flash.bin
  ILINK.IlinkOutputFile: serial_bridge_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c sysclk.c pll.c dfll.c sysclk.h osc.h dfll.h genclk.h pll.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../sam/boards/sam4l_xplained_pro/: init.c led.h sam4l_xplained_pro.h
  group sam/utils
    ../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l_patch_asf.h sam4l.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../sio2ncp/uart/: sio2ncp.c sio2ncp.h
  group thirdparty/wireless/addons/serial_bridge
    ../../../: serial_bridge.c serial_bridge.h
  group thirdparty/wireless/addons/serial_bridge/example
    ../../: main.c
  group thirdparty/wireless/addons/serial_bridge/example/sam4lc4c_sam4l_xplained_pro
    ../: conf_sio2host.h conf_clock.h conf_board.h conf_uart_serial.h conf_sio2ncp.h
  group thirdparty/wireless/addons/serial_bridge/example/sam4lc4c_sam4l_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../sio2host/uart/: sio2host.c sio2host.h
