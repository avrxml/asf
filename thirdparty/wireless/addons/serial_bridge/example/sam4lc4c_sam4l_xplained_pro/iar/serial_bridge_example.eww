<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_bridge_example_flash.ewp</path>
	</project>
</workspace>
