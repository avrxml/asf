<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\zid_unit_tests.ewp</path>
	</project>
</workspace>
