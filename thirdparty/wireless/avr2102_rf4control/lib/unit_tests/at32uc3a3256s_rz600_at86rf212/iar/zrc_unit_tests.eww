<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\zrc_unit_tests.ewp</path>
	</project>
</workspace>
