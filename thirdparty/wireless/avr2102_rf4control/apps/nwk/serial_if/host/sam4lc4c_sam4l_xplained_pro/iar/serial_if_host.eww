<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_if_host_flash.ewp</path>
	</project>
</workspace>
