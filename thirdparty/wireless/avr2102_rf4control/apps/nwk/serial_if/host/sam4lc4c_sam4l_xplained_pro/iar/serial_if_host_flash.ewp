# IAR project serial_if_host_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ENABLE_STACK_NVM; BOARD=SAM4L_XPLAINED_PRO; NLDE_HANDLE; __SAM4LC4C__; ZRC_CMD_DISCOVERY; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; ARM_MATH_CM4=true; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_PLATFORM; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../../common/boards; ../../../../../../addons/serial_interface; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ..; ../../../../../../include; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../avr2025_mac/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../addons/sio2host/uart; ../../../../../../../../../common/services/serial; ../../../../../../../../../sam/boards; ../../../../../../addons/api_parser; ../../../../../../../../../common/utils; ../../../../../../../addons/sio2ncp/uart; ../../../../../../../../../sam/drivers/wdt; ../../../../../../../../../common/services/clock; ../../..; ../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../../common/services/delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/tc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../common/services/ioport; ../../../../../../../../../sam/drivers/bpm; ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial_if_host_flash.bin
  ILINK.IlinkOutputFile: serial_if_host_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h return_val.h avr2025_mac.h mac_build_config.h stack_config.h tal_build_config.h
  group thirdparty/wireless/avr2102_rf4control/addons/api_parser
    ../../../../../../addons/api_parser/: api_parser.c api_parser.h
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../addons/serial_interface/: serial_interface.c serial_interface.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if
    ../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/host
    ../../: conf_common_sw_timer.h app_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/host/sam4lc4c_sam4l_xplained_pro
    ../: conf_sio2host.h conf_clock.h conf_board.h conf_hw_timer.h conf_uart_serial.h conf_sio2ncp.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/host/sam4lc4c_sam4l_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h pb_pairing.h rf4ce.h zrc.h nwk_config.h nwk_build_config.h vendor_data.h nwk_msg_code.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../../../../addons/sio2ncp/uart/: sio2ncp.c sio2ncp.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: osc.h sysclk.h pll.h dfll.h genclk.h
  group common/services/clock/sam4l
    ../../../../../../../../../common/services/clock/sam4l/: osc.c sysclk.c pll.c dfll.c sysclk.h pll.h osc.h dfll.h genclk.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/wdt
    ../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
