<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_if_ncp_flash.ewp</path>
	</project>
</workspace>
