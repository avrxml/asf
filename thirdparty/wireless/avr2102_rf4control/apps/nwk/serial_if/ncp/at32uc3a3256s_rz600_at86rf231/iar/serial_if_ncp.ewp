# IAR project serial_if_ncp.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: TAL_TYPE=AT86RF231; MAC_USER_BUILD_CONFIG; RF4CE_PLATFORM; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; UDD_ENABLE; STB_ON_SAL; RF4CE_SECURITY; BOARD=RZ600; PRIVATE_NIB; RSSI_TO_LQI_MAPPING; NLDE_HANDLE; SAL_TYPE=AT86RF2xx; SIO_HUB; DISABLE_TSTAMP_IRQ=1; CHANNEL_AGILITY; PAL_USE_SPI_TRX=1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../addons/serial_interface; ../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/boards; ../../../../../../../../../common/services/spi/uc3_spi; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../../../common/drivers/nvm; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../avr2025_mac/include; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../avr2025_mac/source/pal/common_hw_timer/uc3; ../../../../../../../../../avr32/drivers/tc; ../../../../../../../addons/sio2host/usb; ../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/utils; ../../../../../../../../../avr32/boards/rz600; ../../../../../../../../../avr32/drivers/spi; ../../../../../../../../../common/services/usb/class/cdc; ../..; ../../../../../../../../../common/services/clock; ../../..; ../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../common/services/usb; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../lib/nwk/config; ../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../../common/services/delay; ../../../../../../../../../common/services/usb/udc; ../../../../../../../../../common/services/spi; ../../../../../../../../../common/boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../common/services/ioport; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr2025_mac/source/tal/at86rf231/inc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/at32uc3a3256s/iar
    ../../../../../../lib/nwk/at32uc3a3256s/iar/: librf4ce-nwk.r82
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/config
    ../../../../../../lib/nwk/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if
    ../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp
    ../../: app_config.h conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp/at32uc3a3256s_rz600_at86rf231
    ../: conf_board.h conf_clock.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_sio2host.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp/at32uc3a3256s_rz600_at86rf231/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../addons/serial_interface/: serial_interface.c serial_interface.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h rf4ce.h pb_pairing.h nwk_build_config.h zrc.h nwk_config.h vendor_data.h nwk_msg_code.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal_ext_trx.c pal.c pal_ext_trx.h pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/uc3/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3/lib
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_poll.c mac_beacon.c mac_data_req.c mac_disassociate.c mac_pib.c mac_misc.c mac_process_tal_tx_frame_status.c mac.c mac_data_extract_mhr.c mac_rx_enable.c mac_mcps_data.c mac_process_beacon_frame.c mac_data_ind.c mac_scan.c mac_tx_coord_realignment_command.c mac_dispatcher.c mac_orphan.c mac_start.c mac_associate.c mac_sync.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac.h mac_api.h mac_msg_const.h mac_internal.h mac_msg_types.h mac_msg_type_data_ind.h mac_security.h mac_data_structures.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf231/src
    ../../../../../../../avr2025_mac/source/tal/at86rf231/src/: tal_pib.c tal_slotted_csma.c tal_init.c tal_rx_enable.c tal.c tal_pwr_mgmt.c tal_tx.c tal_rx.c tal_ed.c tal_irq_handler.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf231/inc
    ../../../../../../../avr2025_mac/source/tal/at86rf231/inc/: tal_config.h tal_constants.h tal_pib.h tal_tx.h tal_rx.h tal_slotted_csma.h tal_irq_handler.h at86rf231.h tal_internal.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../avr2025_mac/source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../../../avr2025_mac/source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../avr2025_mac/source/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h mac_build_config.h avr2025_mac.h tal_build_config.h return_val.h stack_config.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/spi
    ../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../../../common/services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: pll.h genclk.h sysclk.h osc.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/usb
    ../../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../../../../common/services/ioport/uc3/: ioport.h
  group common/drivers/nvm
    ../../../../../../../../../common/drivers/nvm/: common_nvm.h
  group common/drivers/nvm/uc3
    ../../../../../../../../../common/drivers/nvm/uc3/: uc3_nvm.c flash_api.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c power_clocks_lib.h sleep.h pm.h
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/tc
    ../../../../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/rz600
    ../../../../../../../../../avr32/boards/rz600/: led.c init.c led.h rz600.h
  group avr32/utils
    ../../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../avr32/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
