<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_if_ncp.ewp</path>
	</project>
</workspace>
