<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_if_aptr.ewp</path>
	</project>
</workspace>
