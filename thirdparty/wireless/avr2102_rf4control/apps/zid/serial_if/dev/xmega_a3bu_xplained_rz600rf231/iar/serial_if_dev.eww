<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_if_dev.ewp</path>
	</project>
</workspace>
