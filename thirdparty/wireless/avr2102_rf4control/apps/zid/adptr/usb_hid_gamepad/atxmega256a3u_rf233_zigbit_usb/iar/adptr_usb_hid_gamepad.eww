<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adptr_usb_hid_gamepad.ewp</path>
	</project>
</workspace>
