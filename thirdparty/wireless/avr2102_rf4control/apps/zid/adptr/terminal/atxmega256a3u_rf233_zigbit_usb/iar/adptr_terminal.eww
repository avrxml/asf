<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adptr_terminal.ewp</path>
	</project>
</workspace>
