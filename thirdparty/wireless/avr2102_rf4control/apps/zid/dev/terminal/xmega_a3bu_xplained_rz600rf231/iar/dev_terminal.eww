<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dev_terminal.ewp</path>
	</project>
</workspace>
