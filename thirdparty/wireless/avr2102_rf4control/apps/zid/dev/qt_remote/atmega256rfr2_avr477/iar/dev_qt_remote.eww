<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dev_qt_remote.ewp</path>
	</project>
</workspace>
