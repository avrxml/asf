<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dev_key_remote.ewp</path>
	</project>
</workspace>
