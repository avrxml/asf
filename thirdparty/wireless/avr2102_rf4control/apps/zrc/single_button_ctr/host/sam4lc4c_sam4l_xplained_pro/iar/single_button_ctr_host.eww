<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\single_button_ctr_host_flash.ewp</path>
	</project>
</workspace>
