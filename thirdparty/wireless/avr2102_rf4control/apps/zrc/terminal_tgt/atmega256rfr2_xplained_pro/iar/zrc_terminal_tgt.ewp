# IAR project zrc_terminal_tgt.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: ENABLE_STACK_NVM; BOARD=ATMEGA256RFR2_XPLAINED_PRO; NLDE_HANDLE; ZRC_CMD_DISCOVERY; RF4CE_TARGET; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; SAL_TYPE=ATMEGARF_SAL; ZRC_PROFILE; TAL_TYPE=ATMEGARFR2; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../mega/utils/preprocessor; ../../../../../../../../mega/utils; ../../../../../lib/zrc/tgt/config; ../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../include; ../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../avr2025_mac/source/tal/inc; ../../../../../../avr2025_mac/include; ../../../../../../avr2025_mac/source/pal; ../../../../../../avr2025_mac/source/stb/inc; ../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../common/services/serial; ../../../../../../avr2025_mac/source/pal/mega/drivers/tc; ../../../../../../../../mega/boards; ../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../../avr2025_mac/source/tal/atmegarfr2/inc; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../mega/drivers/cpu; ../../../../../../../../common/services/clock; ..; ../../../../../../avr2025_mac/source/pal/common_hw_timer/mega; ../../../../../../../../common/services/delay; ../../../../../../../../mega/drivers/usart; ../../../../../../addons/sio2host/uart; ../../../../../../../../common/services/gpio; ../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../common/services/serial/megarf_usart; ../..; ../../../../../../avr2025_mac/source/pal/mega/drivers/flash; ../../../../../../../../common/boards; ../../../../../../../../common/services/ioport; ../../../../../../../../mega/boards/atmega256rfr2_xplained_pro; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
  XLINK.XclFile: ../link_iar.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ENABLE_STACK_NVM; BOARD=ATMEGA256RFR2_XPLAINED_PRO; NLDE_HANDLE; ZRC_CMD_DISCOVERY; RF4CE_TARGET; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; SAL_TYPE=ATMEGARF_SAL; ZRC_PROFILE; TAL_TYPE=ATMEGARFR2; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../avr2025_mac/source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega/lib
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/mega/lib/: mega_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm
    ../../../../../../avr2025_mac/source/pal/common/drivers/nvm/: common_nvm.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/mega
    ../../../../../../avr2025_mac/source/pal/common/drivers/nvm/mega/: mega_nvm.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/flash
    ../../../../../../avr2025_mac/source/pal/mega/drivers/flash/: flash.c flash.h
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/tc
    ../../../../../../avr2025_mac/source/pal/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../avr2025_mac/source/mac/src/: mac_start.c mac_tx_coord_realignment_command.c mac_sync.c mac_security.c mac_scan.c mac_pib.c mac_data_req.c mac_dispatcher.c mac_data_extract_mhr.c mac_disassociate.c mac_misc.c mac_associate.c mac_process_beacon_frame.c mac_orphan.c mac_rx_enable.c mac_poll.c mac_mcps_data.c mac_beacon.c mac_process_tal_tx_frame_status.c mac.c mac_data_ind.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac.h mac_msg_type_data_ind.h mac_data_structures.h mac_internal.h mac_security.h mac_msg_const.h mac_msg_types.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../../avr2025_mac/source/tal/atmegarfr2/src/: tal_rx_enable.c tal_ed.c tal_tx.c tal.c tal_pib.c tal_irq_handler.c tal_pwr_mgmt.c tal_slotted_csma.c tal_init.c tal_rx.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/inc
    ../../../../../../avr2025_mac/source/tal/atmegarfr2/inc/: tal_pib.h tal_irq_handler.h tal_slotted_csma.h atmega256rfr2.h tal_config.h tal_constants.h tal_internal.h tal_tx.h tal_rx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../avr2025_mac/source/tal/inc/: tal_generic.h tal_timer_config.h tal.h tal_types.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../avr2025_mac/source/stb/src/: stb.c stb_armcrypto.c stb_help.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../avr2025_mac/source/stb/inc/: stb.h stb_generic.h stb_internal.h stb_armcrypto.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/sal/atmegarf_sal/src
    ../../../../../../avr2025_mac/source/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../avr2025_mac/source/sal/inc/: sal.h sal_generic.h sal_types.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../avr2025_mac/include/: mac_build_config.h tal_build_config.h stack_config.h ieee_const.h avr2025_mac.h return_val.h
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/atmega256rfr2/iar
    ../../../../../lib/zrc/tgt/atmega256rfr2/iar/: librf4ce-zrc-target.r90
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/config
    ../../../../../lib/zrc/tgt/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/terminal_tgt
    ../../: vendor_data.c main.c app_config.h conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/terminal_tgt/atmega256rfr2_xplained_pro
    ../: conf_flash.h conf_sio2host.h conf_usart_serial.h conf_clock.h conf_board.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/terminal_tgt/atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../include/: pb_pairing.h rf4ce.h nwk_build_config.h nwk_msg_code.h nwk_config.h vendor_data.h nwk_msg_types.h zrc.h mac_user_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/drivers/usart
    ../../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../../mega/utils/: progmem.h assembler.h compiler.h status_codes.h
  group mega/utils/preprocessor
    ../../../../../../../../mega/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../../mega/utils/assembler/: iar.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../../common/services/ioport/mega/: ioport.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
