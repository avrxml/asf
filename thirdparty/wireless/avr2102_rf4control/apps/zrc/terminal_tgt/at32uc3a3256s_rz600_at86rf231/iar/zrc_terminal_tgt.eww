<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\zrc_terminal_tgt.ewp</path>
	</project>
</workspace>
