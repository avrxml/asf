# IAR project zrc_terminal_tgt_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ENABLE_STACK_NVM; BOARD=SAM4L_XPLAINED_PRO; SAL_TYPE=AT86RF2xx; NLDE_HANDLE; DISABLE_TSTAMP_IRQ=1; MAC_USER_BUILD_CONFIG; RF4CE_TARGET; VENDOR_DATA; ZRC_CMD_DISCOVERY; ENABLE_TRX_SRAM; RF4CE_SECURITY; TAL_TYPE=AT86RF212B; RSSI_TO_LQI_MAPPING; PBP_REC; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; __SAM4LC4C__; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../common/services/spi/sam_spi; ../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../include; ../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../avr2025_mac/include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../avr2025_mac/source/pal; ../../../../../../avr2025_mac/source/stb/inc; ../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../common/services/serial; ..; ../../../../../../../../sam/drivers/spi; ../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../lib/zrc/tgt/config; ../../../../../../avr2025_mac/source/tal/at86rf212b/inc; ../../../../../../addons/sio2host/uart; ../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../../common/services/delay; ../../../../../../../../sam/utils; ../..; ../../../../../../../../sam/drivers/tc; ../../../../../../../../sam/drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../avr2025_mac/source/pal/common_hw_timer/sam; ../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/bpm; ../../../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zrc_terminal_tgt_flash.bin
  ILINK.IlinkOutputFile: zrc_terminal_tgt_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../avr2025_mac/source/pal/: pal_ext_trx.c pal.c pal.h pal_generic.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm
    ../../../../../../avr2025_mac/source/pal/common/drivers/nvm/: common_nvm.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/sam
    ../../../../../../avr2025_mac/source/pal/common/drivers/nvm/sam/: sam_nvm.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/src
    ../../../../../../avr2025_mac/source/tal/at86rf212b/src/: tal.c tal_rx_enable.c tal_rx.c tal_slotted_csma.c tal_pib.c tal_init.c tal_pwr_mgmt.c tal_irq_handler.c tal_ed.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/inc
    ../../../../../../avr2025_mac/source/tal/at86rf212b/inc/: tal_tx.h tal_config.h at86rf212b.h tal_irq_handler.h tal_pib.h tal_slotted_csma.h tal_rx.h tal_internal.h tal_constants.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../avr2025_mac/source/tal/inc/: tal_generic.h tal_timer_config.h tal.h tal_types.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../avr2025_mac/source/mac/src/: mac_start.c mac_tx_coord_realignment_command.c mac_sync.c mac_process_beacon_frame.c mac_mcps_data.c mac_security.c mac_dispatcher.c mac_scan.c mac_pib.c mac_data_req.c mac_data_extract_mhr.c mac_disassociate.c mac_misc.c mac_associate.c mac_orphan.c mac_rx_enable.c mac_data_ind.c mac_poll.c mac_beacon.c mac_process_tal_tx_frame_status.c mac.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac.h mac_msg_type_data_ind.h mac_data_structures.h mac_internal.h mac_security.h mac_msg_const.h mac_msg_types.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../../avr2025_mac/source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../avr2025_mac/source/sal/inc/: sal.h sal_generic.h sal_types.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../avr2025_mac/source/stb/src/: stb.c stb_armcrypto.c stb_help.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../avr2025_mac/source/stb/inc/: stb_generic.h stb.h stb_internal.h stb_armcrypto.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../avr2025_mac/include/: mac_build_config.h tal_build_config.h stack_config.h ieee_const.h avr2025_mac.h return_val.h
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/atsam4lc4c/iar
    ../../../../../lib/zrc/tgt/atsam4lc4c/iar/: librf4ce-zrc-target.a
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/config
    ../../../../../lib/zrc/tgt/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/terminal_tgt
    ../../: vendor_data.c main.c app_config.h conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/terminal_tgt/sam4lc4c_rf212b_zigbit_ext
    ../: conf_sio2host.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/terminal_tgt/sam4lc4c_rf212b_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../include/: pb_pairing.h rf4ce.h nwk_msg_code.h nwk_config.h vendor_data.h nwk_msg_types.h zrc.h nwk_build_config.h mac_user_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h dfll.h genclk.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c pll.c osc.c dfll.h osc.h genclk.h sysclk.h pll.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4l_patch_asf.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
