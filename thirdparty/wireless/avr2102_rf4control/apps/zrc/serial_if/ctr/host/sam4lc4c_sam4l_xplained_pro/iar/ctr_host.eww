<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ctr_host_flash.ewp</path>
	</project>
</workspace>
