<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ctr_ncp.ewp</path>
	</project>
</workspace>
