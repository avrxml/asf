<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ctr_ncp_flash.ewp</path>
	</project>
</workspace>
