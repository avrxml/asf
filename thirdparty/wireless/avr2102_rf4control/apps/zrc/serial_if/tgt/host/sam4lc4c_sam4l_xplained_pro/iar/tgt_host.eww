<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tgt_host_flash.ewp</path>
	</project>
</workspace>
