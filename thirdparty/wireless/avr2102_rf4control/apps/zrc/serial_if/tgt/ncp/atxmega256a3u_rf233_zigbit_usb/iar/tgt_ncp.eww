<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tgt_ncp.ewp</path>
	</project>
</workspace>
