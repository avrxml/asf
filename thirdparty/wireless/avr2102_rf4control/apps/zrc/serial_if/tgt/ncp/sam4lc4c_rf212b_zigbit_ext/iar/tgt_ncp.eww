<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tgt_ncp_flash.ewp</path>
	</project>
</workspace>
