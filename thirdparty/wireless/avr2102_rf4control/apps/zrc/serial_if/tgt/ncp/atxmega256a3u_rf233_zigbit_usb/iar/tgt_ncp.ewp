# IAR project tgt_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: ZRC_CMD_DISCOVERY; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; MAC_USER_BUILD_CONFIG; RF4CE_TARGET; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; BOARD=XMEGA_RF233_ZIGBIT; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; RF4CE_CALLBACK_PARAM; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/xmega; ../../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../../xmega/boards; ../../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../addons/serial_interface; ../../../../../../../../../../xmega/drivers/tc; ../../../../../../../../../../xmega/utils; ../..; ../../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../../../../common/drivers/nvm; ../../../../../../../include; ../../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../../avr2025_mac/include; ../../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../../xmega/boards/xmega_rf233_zigbit; ../../../../../../../../addons/sio2host/usb; ..; ../../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../../common/utils; ../../../../../../../../avr2025_mac/source/tal/at86rf233/inc; ../../../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../../../common/services/clock; ../../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../../common/services/usb; ../../../../../../../../../../common/services/delay; ../../../..; ../../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../../avr2025_mac/source/pal; ../../../../../../../../../../common/services/gpio; ../../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../lib/zrc/tgt/config; ../../../../../../../../../../common/services/usb/udc; ../../../../../../../../../../xmega/drivers/usb; ../../../../../../../../../../common/services/spi; ../../../../../../../../../../common/boards; ../../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ZRC_CMD_DISCOVERY; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; MAC_USER_BUILD_CONFIG; RF4CE_TARGET; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; BOARD=XMEGA_RF233_ZIGBIT; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; RF4CE_CALLBACK_PARAM; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/atxmega256a3u/iar
    ../../../../../../../lib/zrc/tgt/atxmega256a3u/iar/: librf4ce-zrc-target.r90
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/config
    ../../../../../../../lib/zrc/tgt/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../../addons/serial_interface/: serial_interface.c serial_interface.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/serial_if
    ../../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/serial_if/tgt/ncp
    ../../: app_config.h conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/serial_if/tgt/ncp/atxmega256a3u_rf233_zigbit_usb
    ../: conf_sio2host.h conf_clock.h conf_board.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/serial_if/tgt/ncp/atxmega256a3u_rf233_zigbit_usb/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../../include/: zrc.h rf4ce.h pb_pairing.h nwk_msg_code.h nwk_config.h nwk_build_config.h vendor_data.h nwk_msg_types.h mac_user_build_config.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c pal_generic.h pal.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../../avr2025_mac/source/mac/src/: mac_start.c mac_beacon.c mac_process_tal_tx_frame_status.c mac_sync.c mac_misc.c mac_associate.c mac_process_beacon_frame.c mac_data_req.c mac_mcps_data.c mac_data_extract_mhr.c mac_pib.c mac_security.c mac_orphan.c mac_tx_coord_realignment_command.c mac_disassociate.c mac_poll.c mac_data_ind.c mac_rx_enable.c mac_scan.c mac_dispatcher.c mac.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../../avr2025_mac/source/mac/inc/: mac.h mac_security.h mac_msg_type_data_ind.h mac_msg_const.h mac_msg_types.h mac_data_structures.h mac_config.h mac_internal.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../../../../avr2025_mac/source/tal/at86rf233/src/: tal_rx.c tal_pwr_mgmt.c tal_tx.c tal_ed.c tal_pib.c tal.c tal_init.c tal_irq_handler.c tal_slotted_csma.c tal_rx_enable.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../../../../avr2025_mac/source/tal/at86rf233/inc/: tal_internal.h tal_slotted_csma.h tal_irq_handler.h at86rf233.h tal_tx.h tal_config.h tal_constants.h tal_pib.h tal_rx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../../avr2025_mac/source/tal/inc/: tal_generic.h tal_types.h tal_timer_config.h tal_helper.h tal.h
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../../../../avr2025_mac/source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../../avr2025_mac/source/sal/inc/: sal_generic.h sal_types.h sal.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../../avr2025_mac/source/stb/src/: stb_help.c stb_armcrypto.c stb.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../../avr2025_mac/source/stb/inc/: stb_generic.h stb.h stb_armcrypto.h stb_internal.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../../avr2025_mac/include/: stack_config.h return_val.h mac_build_config.h tal_build_config.h ieee_const.h avr2025_mac.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group common/services/spi
    ../../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/usb
    ../../../../../../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../../../../../common/services/usb/udc/: udc.c udi.h udc.h udc_desc.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/xmega
    ../../../../../../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/drivers/nvm
    ../../../../../../../../../../common/drivers/nvm/: common_nvm.h
  group common/drivers/nvm/xmega
    ../../../../../../../../../../common/drivers/nvm/xmega/: xmega_nvm.c
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group xmega/boards/xmega_rf233_zigbit
    ../../../../../../../../../../xmega/boards/xmega_rf233_zigbit/: init.c led.h xmega_rf233_zigbit.h
  group xmega/drivers/spi
    ../../../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/tc
    ../../../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/utils
    ../../../../../../../../../../xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/bit_handling
    ../../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group xmega/utils/assembler
    ../../../../../../../../../../xmega/utils/assembler/: iar.h
