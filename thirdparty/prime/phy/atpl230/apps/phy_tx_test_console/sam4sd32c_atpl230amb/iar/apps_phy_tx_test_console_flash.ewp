# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __FREERTOS__; BOARD=ATPL230AMB; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../include; ../../../../../../../../sam/drivers/rstc; ../../../../../../../../sam/utils/preprocessor; ../..; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../sam/utils/header_files; ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../../../sam/drivers/efc; ../../../../../../../../common/services/serial; ../../../../../../../../sam/drivers/gpbr; ../../../../../../../../common/services/clock; ../../../../../../../../sam/services/flash_efc; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/supc; ../../../../../../../../sam/drivers/pdc; ../../../../../../../../common/utils; ../../../../../../../../sam/services/plc/pplc_if/atpl230; ../../../../../../../../sam/drivers/wdt; ../../../../../../../freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/boards/atpl230amb; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../sam/drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../common/boards; ../../../../coupling_config; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime/phy/atpl230/coupling_config
    ../../../../coupling_config/: conf_atpl230.c conf_atpl230.h
  group thirdparty/prime/phy/atpl230/source
    ../../../../source/: atpl230_iir_filter.c atpl230.c
  group thirdparty/prime/phy/atpl230/apps/phy_tx_test_console
    ../../: phy_embedded_app.c phy_tx_test_console.c phy_embedded_app.h
  group thirdparty/prime/phy/atpl230/apps/phy_tx_test_console/sam4sd32c_atpl230amb
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_pplc_if.h conf_example.h FreeRTOSConfig.h conf_phy.h
  group thirdparty/prime/phy/atpl230/apps/phy_tx_test_console/sam4sd32c_atpl230amb/iar
    ./: asf.h
  group thirdparty/prime/phy/atpl230/include
    ../../../../include/: atpl230_iir_filter.h atpl230.h atpl230_reg.h atpl230_version.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: timers.c queue.c FreeRTOS_CLI.c list.c tasks.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: list.h FreeRTOS.h timers.h projdefs.h semphr.h StackMacros.h mpu_wrappers.h croutine.h task.h portable.h FreeRTOS_CLI.h queue.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../../../../../sam/drivers/rstc/example1/: rstc_example1.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s4a.h sam4s4c.h sam4s8c.h sam4sd32b.h sam4s16b.h sam4sa16b.h sam4s2c.h sam4sa16c.h sam4s2a.h system_sam4s.h sam4sd16c.h sam4s8b.h sam4s.h sam4s4b.h sam4sd32c.h sam4s16c.h sam4s2b.h sam4sd16b.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_pio.h component_smc.h component_gpbr.h component_cmcc.h component_rtc.h component_dacc.h component_ssc.h component_matrix.h component_tc.h component_rtt.h component_uart.h component_rstc.h component_chipid.h component_pwm.h component_pmc.h component_udp.h component_wdt.h component_supc.h component_crccu.h component_usart.h component_twi.h component_hsmci.h component_pdc.h component_acc.h component_efc.h component_spi.h component_adc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4sd16b.h pio_sam4s2a.h pio_sam4sa16c.h pio_sam4s16c.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4s2b.h pio_sam4s8c.h pio_sam4sd32c.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s16b.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_cmcc.h instance_crccu.h instance_efc0.h instance_chipid.h instance_tc0.h instance_usart0.h instance_pmc.h instance_dacc.h instance_piob.h instance_uart1.h instance_twi0.h instance_hsmci.h instance_efc1.h instance_acc.h instance_spi.h instance_adc.h instance_ssc.h instance_tc1.h instance_pwm.h instance_udp.h instance_wdt.h instance_rtc.h instance_uart0.h instance_matrix.h instance_twi1.h instance_supc.h instance_rtt.h instance_usart1.h instance_gpbr.h instance_smc.h instance_pioa.h instance_pioc.h instance_rstc.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/services/plc/pplc_if/atpl230
    ../../../../../../../../sam/services/plc/pplc_if/atpl230/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/atpl230amb
    ../../../../../../../../sam/boards/atpl230amb/: init.c atpl230amb.h led.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../../../common/services/clock/sam4s/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
