# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __FREERTOS__; ARM_MATH_CM4=true; __SAM4CP16B_0__; BOARD=SAM4CP16BMB
  ICCARM.CCIncludePath2: ../../../../include; ../../../../../../../../sam/drivers/rstc; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/utils/cmsis/sam4cp/source/templates; ../../../../../../../../sam/utils/header_files; ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../../../sam/drivers/efc; ../../../../../../../../common/services/serial; ../../../../../../../../sam/drivers/gpbr; ../../../../../../../../sam/utils/cmsis/sam4cp/include; ../../../../../../../../common/services/clock; ../..; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/supc; ../../../../../../../../sam/drivers/pdc; ../../../../../../../../sam/services/flash_efc; ../../../../../../../../sam/boards/sam4cp16bmb; ../../../../../../../../sam/services/plc/pplc_if/atpl230; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/boards; ..; ../../../../../../../../sam/drivers/trng; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../common/boards; ../../../../coupling_config; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/pmc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime/phy/atpl230/coupling_config
    ../../../../coupling_config/: conf_atpl230.c conf_atpl230.h
  group thirdparty/prime/phy/atpl230/source
    ../../../../source/: atpl230_iir_filter.c atpl230.c
  group thirdparty/prime/phy/atpl230/apps/phy_tx_test_console
    ../../: phy_embedded_app.c phy_tx_test_console.c phy_embedded_app.h
  group thirdparty/prime/phy/atpl230/apps/phy_tx_test_console/sam4cp16b_sam4cp16bmb
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_example.h FreeRTOSConfig.h conf_phy.h
  group thirdparty/prime/phy/atpl230/apps/phy_tx_test_console/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group thirdparty/prime/phy/atpl230/include
    ../../../../include/: atpl230_iir_filter.h atpl230.h atpl230_reg.h atpl230_version.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: timers.c queue.c FreeRTOS_CLI.c list.c tasks.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: portable.h list.h FreeRTOS_CLI.h FreeRTOS.h queue.h timers.h projdefs.h semphr.h StackMacros.h mpu_wrappers.h croutine.h task.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4cp
    ../../../../../../../../common/services/clock/sam4cp/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/: sam4cp16b_0.h sam4cp16b_1.h sam4cp_1.h system_sam4cp.h sam4cp_0.h sam4cp.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/instance/: instance_gpbr.h instance_twi0.h instance_rtc.h instance_trng.h instance_uart0.h instance_twi1.h instance_cmcc0.h instance_usart1.h instance_rswdt.h instance_pmc.h instance_chipid.h instance_ipc1.h instance_usart3.h instance_piob.h instance_uart1.h instance_rtt.h instance_rstc.h instance_matrix1.h instance_pioa.h instance_usart0.h instance_efc.h instance_cmcc1.h instance_slcdc.h instance_usart2.h instance_supc.h instance_wdt.h instance_usart4.h instance_tc1.h instance_spi0.h instance_matrix0.h instance_pwm.h instance_smc0.h instance_ipc0.h instance_tc0.h instance_smc1.h instance_icm.h instance_spi1.h instance_pioc.h instance_adc.h instance_aes.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/component/: component_rstc.h component_supc.h component_efc.h component_pdc.h component_pwm.h component_usart.h component_twi.h component_icm.h component_slcdc.h component_aes.h component_pmc.h component_chipid.h component_wdt.h component_rswdt.h component_smc.h component_gpbr.h component_trng.h component_spi.h component_ipc.h component_cmcc.h component_rtc.h component_rtt.h component_pio.h component_adc.h component_matrix.h component_uart.h component_tc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/services/plc/pplc_if/atpl230
    ../../../../../../../../sam/services/plc/pplc_if/atpl230/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/sam4cp16bmb
    ../../../../../../../../sam/boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
