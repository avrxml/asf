<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\addons_bootloader_flash.ewp</path>
	</project>
</workspace>
