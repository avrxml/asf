# IAR project addons_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../sam/utils; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/boards/sam4cp16bmb; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/services/flash_efc; ../../../../../../../../sam/utils/cmsis/sam4cp/source/templates; ../../../../../../../../sam/drivers/supc; ../../../../../../../../common/utils; ../../../../../../../../sam/utils/cmsis/sam4cp/include; ..; ../../../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: addons_bootloader_flash.bin
  ILINK.IlinkOutputFile: addons_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../linker_scripts/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/: sam4cp16b_0.h sam4cp16b_1.h sam4cp_1.h system_sam4cp.h sam4cp_0.h sam4cp.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/instance/: instance_gpbr.h instance_twi0.h instance_rtc.h instance_trng.h instance_uart0.h instance_smc0.h instance_twi1.h instance_cmcc0.h instance_usart0.h instance_usart1.h instance_pmc.h instance_rswdt.h instance_chipid.h instance_ipc1.h instance_usart3.h instance_piob.h instance_uart1.h instance_rtt.h instance_matrix0.h instance_matrix1.h instance_pioa.h instance_pioc.h instance_efc.h instance_cmcc1.h instance_slcdc.h instance_usart2.h instance_supc.h instance_wdt.h instance_usart4.h instance_tc1.h instance_spi0.h instance_rstc.h instance_pwm.h instance_ipc0.h instance_tc0.h instance_smc1.h instance_icm.h instance_spi1.h instance_adc.h instance_aes.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/component/: component_spi.h component_rstc.h component_supc.h component_efc.h component_pdc.h component_twi.h component_icm.h component_slcdc.h component_usart.h component_aes.h component_pmc.h component_chipid.h component_wdt.h component_rswdt.h component_smc.h component_gpbr.h component_trng.h component_ipc.h component_cmcc.h component_rtc.h component_rtt.h component_pwm.h component_pio.h component_adc.h component_matrix.h component_uart.h component_tc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4cp16bmb
    ../../../../../../../../sam/boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4cp
    ../../../../../../../../common/services/clock/sam4cp/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader
    ../../: bootloader.c boot_regions_sam4cp16b_0.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader/sam4cp16b_sam4cp16bmb
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_version.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
