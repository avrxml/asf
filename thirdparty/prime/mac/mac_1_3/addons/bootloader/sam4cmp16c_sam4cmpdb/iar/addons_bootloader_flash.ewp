# IAR project addons_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMP16C_0 Atmel ATSAM4CMP16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../sam/utils; ../../../../../../../../common/services/clock; ../../../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/boards/sam4cmp_db; ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/services/flash_efc; ../../../../../../../../sam/boards; ../../../../../../../../common/utils; ..; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: addons_bootloader_flash.bin
  ILINK.IlinkOutputFile: addons_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../linker_scripts/iar/sam4cmp16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_0.h sam4cmp8c_0.h sam4cms16c_1.h sam4cmp16c_0.h sam4cmp8c_1.h sam4cm.h system_sam4cm.h sam4cms8c_1.h sam4cms16c_0.h sam4cmp16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: cmcc0.h efc.h smc1.h wdt.h ipc1.h uart1.h spi0.h twi1.h rtc.h matrix0.h chipid.h usart3.h usart0.h usart2.h rtt.h tc0.h tc1.h rswdt.h adc.h gpbr.h ipc0.h pioa.h pmc.h pioc.h matrix1.h uart0.h usart1.h rstc.h twi0.h supc.h smc0.h trng.h slcdc.h cmcc1.h piob.h pwm.h icm.h spi1.h aes.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: gpbr.h tc.h rtc.h adc.h chipid.h matrix.h rswdt.h rstc.h efc.h slcdc.h twi.h pwm.h trng.h rtt.h supc.h pdc.h spi.h pio.h smc.h pmc.h uart.h aes.h icm.h usart.h wdt.h ipc.h cmcc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cmp8c.h sam4cms16c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/boards/sam4cmp_db
    ../../../../../../../../sam/boards/sam4cmp_db/: init.c sam4cmp_db.h led.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4cm
    ../../../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader
    ../../: bootloader.c boot_regions_sam4cmp16c_0.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader/sam4cmp16c_sam4cmpdb
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_version.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader/sam4cmp16c_sam4cmpdb/iar
    ./: asf.h
