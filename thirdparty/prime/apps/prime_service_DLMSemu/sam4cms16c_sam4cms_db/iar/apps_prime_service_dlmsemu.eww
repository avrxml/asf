<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_prime_service_dlmsemu_flash.ewp</path>
	</project>
</workspace>
