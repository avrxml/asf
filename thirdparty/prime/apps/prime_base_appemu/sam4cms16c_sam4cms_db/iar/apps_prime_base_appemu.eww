<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_prime_base_appemu_flash.ewp</path>
	</project>
</workspace>
