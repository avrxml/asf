<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_prime_service_dlmsemu_uc_flash.ewp</path>
	</project>
</workspace>
