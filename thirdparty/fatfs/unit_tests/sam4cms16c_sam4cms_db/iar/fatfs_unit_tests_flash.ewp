# IAR project fatfs_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM4CMS16C_0__; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; BOARD=SAM4CMS_DB; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ..; ../../../../../common/components/memory/virtual_mem; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../sam/boards/sam4cms_db; ../..; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_unit_tests_flash.bin
  ILINK.IlinkOutputFile: fatfs_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4cm
    ../../../../../common/services/clock/sam4cm/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/boards/sam4cms_db
    ../../../../../sam/boards/sam4cms_db/: init.c sam4cms_db.h led.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../sam/utils/cmsis/sam4cm/include/: sam4cmp16c_0.h sam4cmp8c_1.h sam4cms16c_1.h sam4cm.h sam4cmp16c_1.h sam4cms16c_0.h sam4cmp8c_0.h sam4cms8c_0.h system_sam4cm.h sam4cms8c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../sam/utils/cmsis/sam4cm/include/instance/: matrix0.h cmcc0.h wdt.h icm.h rtc.h rswdt.h uart1.h usart2.h chipid.h smc0.h cmcc1.h supc.h ipc0.h gpbr.h usart3.h tc1.h spi0.h ipc1.h pmc.h pwm.h pioc.h slcdc.h adc.h aes.h tc0.h spi1.h twi0.h pioa.h rtt.h piob.h matrix1.h rstc.h usart0.h efc.h uart0.h usart1.h twi1.h trng.h smc1.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../sam/utils/cmsis/sam4cm/include/component/: matrix.h pmc.h pio.h icm.h rswdt.h adc.h cmcc.h uart.h trng.h usart.h wdt.h spi.h chipid.h supc.h gpbr.h aes.h smc.h efc.h rstc.h rtc.h pdc.h pwm.h tc.h rtt.h twi.h slcdc.h ipc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms16c.h sam4cmp8c.h sam4cms8c.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/unit_tests/sam4cms16c_sam4cms_db
    ../: conf_virtual_mem.h conf_uart_serial.h conf_test.h conf_clock.h conf_board.h conf_access.h conf_fatfs.h
  group thirdparty/fatfs/unit_tests/sam4cms16c_sam4cms_db/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
