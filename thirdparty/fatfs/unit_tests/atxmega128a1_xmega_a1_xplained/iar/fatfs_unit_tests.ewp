# IAR project fatfs_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; BOARD=XMEGA_A1_XPLAINED; VIRTUAL_MEMORY_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../xmega/utils; ../../../fatfs-r0.09/src; ../../../../../common/services/calendar; ../../../../../common/components/memory/virtual_mem; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../common/services/serial/xmega_usart; ../../../../../xmega/drivers/usart; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../xmega/drivers/ebi; ../../../../../common/services/clock; ../../../../../common/utils/stdio/stdio_serial; ../../../../../xmega/boards/xmega_a1_xplained; ../../../fatfs-port-r0.09/xmega; ../../../../../xmega/boards; ../..; ../../../../../common/services/gpio; ..; ../../../../../common/boards; ../../../../../xmega/drivers/rtc; ../../../../../common/services/hugemem; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/sleep; ../../../../../xmega/drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; BOARD=XMEGA_A1_XPLAINED; VIRTUAL_MEMORY_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/hugemem
    ../../../../../common/services/hugemem/: hugemem.h
  group common/services/hugemem/avr8
    ../../../../../common/services/hugemem/avr8/: avr8_hugemem.c hugemem.h
  group common/services/hugemem/generic
    ../../../../../common/services/hugemem/generic/: hugemem.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/calendar
    ../../../../../common/services/calendar/: calendar.c calendar.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../common/services/serial/xmega_usart/: usart_serial.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_xmega.c memories_initialization.h
  group thirdparty/fatfs/unit_tests/atxmega128a1_xmega_a1_xplained
    ../: conf_test.h conf_access.h conf_clock.h conf_virtual_mem.h conf_fatfs.h conf_board.h conf_sleepmgr.h conf_usart_serial.h conf_rtc.h
  group thirdparty/fatfs/unit_tests/atxmega128a1_xmega_a1_xplained/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c ffconf.h integer.h diskio.h ff.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../fatfs-port-r0.09/xmega/: fattime.c
  group xmega/drivers/rtc
    ../../../../../xmega/drivers/rtc/: rtc.c rtc.h
  group xmega/drivers/ebi
    ../../../../../xmega/drivers/ebi/: ebi.c ebi.h ebi_port.h
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../xmega/boards/xmega_a1_xplained/: init.c xmega_a1_xplained.h led.h
  group xmega/utils
    ../../../../../xmega/utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/bit_handling
    ../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/assembler
    ../../../../../xmega/utils/assembler/: iar.h
