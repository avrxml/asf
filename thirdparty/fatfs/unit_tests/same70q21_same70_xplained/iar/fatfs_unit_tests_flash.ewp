# IAR project fatfs_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAME70Q21B__; BOARD=SAME70_XPLAINED; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../sam/utils/preprocessor; ../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../sam/utils/cmsis/same70/include; ../../../../../common/components/memory/virtual_mem; ../../../../../sam/utils/fpu; ../../../../../common/services/gpio; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/drivers/mpu; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../sam/boards/same70_xplained; ../..; ..; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_unit_tests_flash.bin
  ILINK.IlinkOutputFile: fatfs_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/same70
    ../../../../../common/services/clock/same70/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/unit_tests/same70q21_same70_xplained
    ../: conf_virtual_mem.h conf_uart_serial.h conf_board.h conf_clock.h conf_test.h conf_access.h conf_fatfs.h
  group thirdparty/fatfs/unit_tests/same70q21_same70_xplained/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../sam/utils/cmsis/same70/include/: same70n19.h same70n21b.h same70n21.h same70j20b.h same70j21.h same70q19b.h same70j19b.h same70q20.h same70q20b.h same70j19.h same70j21b.h same70j20.h same70n20.h same70n19b.h same70.h same70q21.h same70q21b.h same70q19.h same70n20b.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../sam/utils/cmsis/same70/include/pio/: same70j19.h same70q21b.h same70j21b.h same70q20.h same70j19b.h same70q19b.h same70q19.h same70j20.h same70n20.h same70j21.h same70n19.h same70n20b.h same70q21.h same70q20b.h same70n21b.h same70j20b.h same70n19b.h same70n21.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../sam/utils/cmsis/same70/include/component/: supc.h pio.h hsmci.h xdmac.h isi.h trng.h rswdt.h usbhs.h rstc.h gmac.h gpbr.h pwm.h dacc.h utmi.h icm.h qspi.h pmc.h efc.h rtt.h aes.h spi.h twihs.h afec.h mcan.h i2sc.h matrix.h uart.h wdt.h smc.h ssc.h usart.h chipid.h tc.h rtc.h acc.h sdramc.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../sam/utils/cmsis/same70/include/instance/: hsmci.h tc1.h twihs1.h aes.h i2sc1.h icm.h efc.h spi0.h rswdt.h uart2.h qspi.h uart4.h xdmac.h tc3.h sdramc.h utmi.h uart0.h rtt.h trng.h spi1.h uart3.h usart1.h matrix.h piod.h dacc.h tc0.h acc.h pmc.h ssc.h piob.h usart0.h pwm0.h afec1.h i2sc0.h tc2.h twihs2.h uart1.h mcan1.h pioe.h smc.h chipid.h isi.h usart2.h rtc.h wdt.h mcan0.h pioc.h pwm1.h afec0.h usbhs.h supc.h rstc.h gpbr.h twihs0.h gmac.h pioa.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/mpu
    ../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/boards/same70_xplained
    ../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
