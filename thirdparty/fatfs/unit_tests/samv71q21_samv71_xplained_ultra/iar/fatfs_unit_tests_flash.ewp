# IAR project fatfs_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21B Atmel ATSAMV71Q21B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; __SAMV71Q21B__
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ..; ../../../fatfs-port-r0.09/sam; ../../../../../common/components/memory/virtual_mem; ../../../../../sam/utils/fpu; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/drivers/mpu; ../../../../../common/utils; ../../../../../sam/utils/cmsis/samv71/source/templates; ../../../../../sam/boards/samv71_xplained_ultra; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../common/services/gpio; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../sam/utils/cmsis/samv71/include; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_unit_tests_flash.bin
  ILINK.IlinkOutputFile: fatfs_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/samv71
    ../../../../../common/services/clock/samv71/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/unit_tests/samv71q21_samv71_xplained_ultra
    ../: conf_virtual_mem.h conf_uart_serial.h conf_test.h conf_clock.h conf_board.h conf_access.h conf_fatfs.h
  group thirdparty/fatfs/unit_tests/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../sam/utils/cmsis/samv71/include/: samv71q19b.h samv71j19.h samv71n19b.h samv71n20b.h samv71n19.h samv71q19.h samv71q20.h samv71q21b.h samv71j20b.h samv71j21.h samv71q21.h samv71n21.h samv71j21b.h samv71j19b.h samv71n20.h samv71q20b.h samv71.h samv71j20.h samv71n21b.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../sam/utils/cmsis/samv71/include/pio/: samv71n19.h samv71n21b.h samv71q21.h samv71q20b.h samv71n19b.h samv71n20.h samv71q20.h samv71q21b.h samv71j19.h samv71j20b.h samv71q19b.h samv71j20.h samv71n21.h samv71j21b.h samv71n20b.h samv71j19b.h samv71q19.h samv71j21.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../sam/utils/cmsis/samv71/include/instance/: mcan0.h i2sc1.h gpbr.h spi0.h efc.h piob.h pwm1.h icm.h trng.h aes.h matrix.h uart4.h twihs1.h mlb.h spi1.h ssc.h rstc.h pioc.h tc1.h piod.h rtt.h chipid.h xdmac.h afec1.h i2sc0.h pmc.h dacc.h tc3.h uart1.h wdt.h sdramc.h rswdt.h uart2.h twihs0.h pioe.h rtc.h uart0.h usart1.h isi.h pioa.h smc.h twihs2.h afec0.h gmac.h usart2.h mcan1.h tc2.h utmi.h qspi.h usbhs.h uart3.h tc0.h pwm0.h usart0.h hsmci.h supc.h acc.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../sam/utils/cmsis/samv71/include/component/: mcan.h rtt.h aes.h usbhs.h mlb.h sdramc.h pwm.h acc.h isi.h pio.h efc.h tc.h uart.h i2sc.h usart.h rswdt.h xdmac.h pmc.h qspi.h twihs.h wdt.h afec.h hsmci.h icm.h dacc.h smc.h utmi.h gmac.h gpbr.h ssc.h rstc.h supc.h spi.h chipid.h rtc.h matrix.h trng.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/mpu
    ../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../sam/boards/samv71_xplained_ultra/: init.c samv71_xplained_ultra.h led.h
