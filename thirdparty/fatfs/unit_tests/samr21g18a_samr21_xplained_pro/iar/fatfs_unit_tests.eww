<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fatfs_unit_tests_flash.ewp</path>
	</project>
</workspace>
