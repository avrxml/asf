# IAR project fatfs_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; __SAM4C16C_0__; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../sam/utils/header_files; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../common/components/memory/virtual_mem; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/utils/cmsis/sam4c/source/templates; ../../../../../sam/boards/sam4c_ek; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../common/services/serial/sam_uart; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/utils/cmsis/sam4c/include; ..; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/usart; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_unit_tests_flash.bin
  ILINK.IlinkOutputFile: fatfs_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4c
    ../../../../../common/services/clock/sam4c/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/unit_tests/sam4c16c_sam4c_ek
    ../: conf_virtual_mem.h conf_uart_serial.h conf_test.h conf_clock.h conf_board.h conf_access.h conf_fatfs.h
  group thirdparty/fatfs/unit_tests/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../sam/utils/cmsis/sam4c/include/: sam4c32e_0.h sam4c32c_1.h sam4c16c_0.h sam4c16c_1.h sam4c32e_1.h system_sam4c.h sam4c.h sam4c8c_1.h sam4c8c_0.h sam4c32c_0.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_uotghs.h instance_spi1.h instance_gpbr.h instance_wdt.h instance_pmc.h instance_matrix0.h instance_cmcc1.h instance_uart0.h instance_tc0.h instance_icm.h instance_supc.h instance_twi1.h instance_adc.h instance_ipc1.h instance_matrix1.h instance_pioc.h instance_rstc.h instance_cmcc0.h instance_pioa.h instance_slcdc.h instance_usart1.h instance_ipc0.h instance_twi0.h instance_spi0.h instance_rtt.h instance_tc1.h instance_piod.h instance_efc1.h instance_piob.h instance_smc0.h instance_usart4.h instance_usart2.h instance_chipid.h instance_efc.h instance_smc1.h instance_rtc.h instance_rswdt.h instance_usart0.h instance_aes.h instance_efc0.h instance_uart1.h instance_usart3.h instance_trng.h instance_pwm.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../sam/utils/cmsis/sam4c/include/component/: component_rswdt.h component_uart.h component_wdt.h component_efc.h component_pwm.h component_spi.h component_slcdc.h component_chipid.h component_rtc.h component_rstc.h component_adc.h component_ipc.h component_gpbr.h component_smc.h component_cmcc.h component_usart.h component_supc.h component_pdc.h component_uotghs.h component_icm.h component_pmc.h component_matrix.h component_pio.h component_trng.h component_aes.h component_twi.h component_tc.h component_rtt.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c32c.h pio_sam4c16c.h pio_sam4c8c.h pio_sam4c32e.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/boards/sam4c_ek
    ../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
