# IAR project fatfs_access_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: AT45DBX_ENABLE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../common/services/spi/xmega_spi; ..; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../xmega/utils; ../../../fatfs-r0.09/src; ../../../../../common/services/calendar; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../common/services/serial/xmega_usart; ../../../../../xmega/drivers/usart; ../../../../../xmega/drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../xmega/drivers/rtc32; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/clock; ../..; ../../../../../xmega/boards/xmega_a3bu_xplained; ../../../fatfs-port-r0.09/xmega; ../../../../../xmega/boards; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../../common/services/hugemem; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../../xmega/drivers/spi; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/sleep; ../../../../../xmega/drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; AT45DBX_ENABLE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h usart_spi.h
  group common/services/spi/xmega_spi
    ../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/hugemem
    ../../../../../common/services/hugemem/: hugemem.h
  group common/services/hugemem/avr8
    ../../../../../common/services/hugemem/avr8/: avr8_hugemem.c hugemem.h
  group common/services/hugemem/generic
    ../../../../../common/services/hugemem/generic/: hugemem.h
  group common/services/calendar
    ../../../../../common/services/calendar/: calendar.c calendar.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../common/services/serial/xmega_usart/: usart_serial.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx_hal_spi.h at45dbx_mem.h at45dbx.h
  group common/boards
    ../../../../../common/boards/: board.h
  group xmega/drivers/spi
    ../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/nvm
    ../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/rtc32
    ../../../../../xmega/drivers/rtc32/: rtc32.c rtc32.h
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../xmega/utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/bit_handling
    ../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/assembler
    ../../../../../xmega/utils/assembler/: iar.h
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_xmega.c memories_initialization.h
  group thirdparty/fatfs/example/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_usart_spi.h conf_access.h conf_clock.h conf_fatfs.h conf_board.h conf_at45dbx.h conf_sleepmgr.h conf_spi_master.h conf_usart_serial.h conf_rtc32.h
  group thirdparty/fatfs/example/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../fatfs-port-r0.09/xmega/: fattime.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ffconf.h integer.h ff.h
