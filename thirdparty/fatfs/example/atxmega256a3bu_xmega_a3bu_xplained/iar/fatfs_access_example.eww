<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fatfs_access_example.ewp</path>
	</project>
</workspace>
