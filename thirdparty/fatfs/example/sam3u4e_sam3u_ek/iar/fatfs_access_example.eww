<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fatfs_access_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\fatfs_access_example_sram.ewp</path>
	</project>
</workspace>
