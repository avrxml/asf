# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; CYCLE_MODE; RTC_CALENDAR_ASYNC=false; SD_MMC_ENABLE; __SAMR21G18A__; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true; BOARD=SAMR21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../sam0/drivers/system/clock/clock_samd21_r21; ..; ../../../../../sam0/drivers/port; ../../../../../sam0/utils/cmsis/samr21/include/instance; ../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../sam0/utils/preprocessor; ../../../fatfs-r0.09/src; ../../../../../sam0/utils/cmsis/samr21/source; ../../../../../common2/services/delay; ../../../../../sam0/utils; ../../../../../sam0/drivers/sercom/spi; ../../../../../sam0/drivers/sercom; ../../../../../sam0/boards; ../../../../../sam0/drivers/sercom/usart; ../../../../../common/services/serial; ../..; ../../../../../common/utils; ../../../../../sam0/drivers/system/interrupt; ../../../../../sam0/boards/samr21_xplained_pro; ../../../../../sam0/drivers/rtc; ../../../../../sam0/utils/cmsis/samr21/include/pio; ../../../../../sam0/utils/cmsis/samr21/include/component; ../../../../../common2/services/delay/sam0; ../../../fatfs-port-r0.09/sam0; ../../../../../sam0/utils/cmsis/samr21/include; ../../../../../common/boards; ../../../../../sam0/drivers/system/pinmux; ../../../../../sam0/drivers/system; ../../../../../common2/components/memory/sd_mmc; ../../../../../sam0/utils/header_files; ../../../../../sam0/utils/stdio/stdio_serial; ../../../../../common/services/storage/ctrl_access; ../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam0/drivers/system
    ../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../sam0/drivers/system/clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/pinmux
    ../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/sercom
    ../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/usart
    ../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../../sam0/drivers/rtc/: rtc_calendar.c rtc_calendar.h
  group sam0/drivers/rtc/quick_start_calendar
    ../../../../../sam0/drivers/rtc/quick_start_calendar/: qs_rtc_calendar_basic.h
  group sam0/utils
    ../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../sam0/utils/cmsis/samr21/include/: samr21e16a.h samr21.h samr21e17a.h samr21g18a.h samr21g17a.h samr21e18a.h samr21g16a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../sam0/utils/cmsis/samr21/include/component/: component_rfctrl.h component_adc.h component_ac.h component_eic.h component_wdt.h component_port.h component_rtc.h component_dac.h component_mtb.h component_tcc.h component_i2s.h component_tc.h component_nvmctrl.h component_sercom.h component_evsys.h component_dmac.h component_pac.h component_sysctrl.h component_dsu.h component_pm.h component_gclk.h component_usb.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../sam0/utils/cmsis/samr21/include/pio/: pio_samr21e18a.h pio_samr21g17a.h pio_samr21e16a.h pio_samr21g18a.h pio_samr21g16a.h pio_samr21e17a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../sam0/utils/cmsis/samr21/include/instance/: instance_nvmctrl.h instance_tc6.h instance_tc4.h instance_dac.h instance_tcc1.h instance_tc3.h instance_sercom0.h instance_port.h instance_dsu.h instance_gclk.h instance_sercom2.h instance_dmac.h instance_sercom4.h instance_pac1.h instance_rfctrl.h instance_tc7.h instance_tc5.h instance_tcc0.h instance_ac.h instance_sercom1.h instance_sercom3.h instance_adc.h instance_sercom5.h instance_i2s.h instance_pac0.h instance_mtb.h instance_tcc2.h instance_evsys.h instance_pac2.h instance_rtc.h instance_usb.h instance_eic.h instance_sysctrl.h instance_pm.h instance_wdt.h
  group sam0/utils/preprocessor
    ../../../../../sam0/utils/preprocessor/: preprocessor.h tpaste.h mrepeat.h stringz.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group thirdparty/fatfs/example
    ../../: memories_initialization_sam0.c fatfs_access_example.c memories_initialization.h
  group thirdparty/fatfs/example/samr21g18a_samr21_xplained_pro
    ../: conf_board.h conf_sd_mmc.h conf_access.h conf_fatfs.h conf_spi.h conf_clocks.h
  group thirdparty/fatfs/example/samr21g18a_samr21_xplained_pro/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../fatfs-port-r0.09/sam0/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
  group common2/components/memory/sd_mmc
    ../../../../../common2/components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc_protocol.h sd_mmc_mem.h sd_mmc_spi.h sd_mmc.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
