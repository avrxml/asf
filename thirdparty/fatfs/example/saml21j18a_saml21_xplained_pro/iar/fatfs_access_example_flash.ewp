# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CYCLE_MODE; RTC_CALENDAR_ASYNC=false; SD_MMC_ENABLE; __SAML21J18A__; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..; ../../../../../sam0/drivers/system/power; ../../../../../sam0/drivers/system/reset; ../../../../../sam0/boards/saml21_xplained_pro; ../../../../../common2/services/delay; ../../../../../sam0/utils/preprocessor; ../../../fatfs-r0.09/src; ../../../../../sam0/drivers/rtc/rtc_sam_l_c; ../../../../../sam0/utils; ../../../../../sam0/drivers/sercom/spi; ../../../../../sam0/drivers/sercom; ../../../../../sam0/drivers/port; ../../../../../sam0/boards; ../../../../../sam0/drivers/sercom/usart; ../../../../../common/services/serial; ../..; ../../../../../common/utils; ../../../../../sam0/drivers/system/interrupt; ../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../sam0/drivers/rtc; ../../../../../sam0/utils/header_files; ../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../common2/services/delay/sam0; ../../../fatfs-port-r0.09/sam0; ../../../../../sam0/utils/cmsis/saml21/include; ../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../common/boards; ../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../sam0/drivers/system/pinmux; ../../../../../sam0/drivers/system; ../../../../../common2/components/memory/sd_mmc; ../../../../../sam0/utils/cmsis/saml21/source; ../../../../../sam0/utils/stdio/stdio_serial; ../../../../../common/services/storage/ctrl_access; ../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/example
    ../../: memories_initialization_sam0.c fatfs_access_example.c memories_initialization.h
  group thirdparty/fatfs/example/saml21j18a_saml21_xplained_pro
    ../: conf_rtc.h conf_board.h conf_sd_mmc.h conf_access.h conf_fatfs.h conf_spi.h conf_clocks.h
  group thirdparty/fatfs/example/saml21j18a_saml21_xplained_pro/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../fatfs-port-r0.09/sam0/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
  group common2/components/memory/sd_mmc
    ../../../../../common2/components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc_protocol.h sd_mmc_mem.h sd_mmc_spi.h sd_mmc.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
  group sam0/drivers/sercom
    ../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom.h sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/usart
    ../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/system
    ../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/rtc
    ../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_calendar.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../sam0/drivers/rtc/rtc_sam_l_c/: rtc_calendar.c
  group sam0/drivers/port
    ../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../sam0/utils/cmsis/saml21/include/: saml21.h saml21j18a.h saml21e18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../sam0/utils/cmsis/saml21/include/component/: adc_100.h ac.h dmac.h pm_100.h port.h nvmctrl_301.h mtb.h evsys.h wdt.h aes.h tcc_200.h gclk_100.h rstc_100.h ccl.h trng.h eic_100.h rtc_100.h dsu.h tal.h sercom.h tc_100.h usb.h oscctrl.h pac_100.h dac.h supc_100.h mclk_100.h opamp.h osc32kctrl.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../sam0/utils/cmsis/saml21/include/instance/: mclk_100.h tcc1_200.h usb.h dsu.h dmac.h pac_100.h sercom2.h dac.h tc3_100.h sercom0.h oscctrl.h ac.h tcc0_200.h sercom4.h tc1_100.h sercom3.h rstc_100.h sercom1.h mtb.h evsys.h pm_100.h sercom5.h tal.h ccl.h eic_100.h opamp.h nvmctrl_301.h port.h tc2_100.h aes.h tcc2_200.h rtc_100.h gclk_100.h trng.h adc_100.h supc_100.h osc32kctrl.h tc0_100.h tc4_100.h wdt.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21j18a.h saml21e18a.h saml21g18a.h
  group sam0/utils/preprocessor
    ../../../../../sam0/utils/preprocessor/: preprocessor.h tpaste.h mrepeat.h stringz.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
