# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK; AT45DBX_ENABLE
  ICCARM.CCIncludePath2: ../../../../../common/services/serial; ../../../../../common/services/spi/sam_spi; ../../../../../sam/utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../sam/drivers/ebi/smc; ../../../../../sam/utils/cmsis/sam3s/include; ../../../../../common/services/ioport; ../../../../../sam/drivers/spi; ../..; ../../../../../common/utils; ../../../../../sam/utils/cmsis/sam3s/source/templates; ..; ../../../../../sam/boards/sam3s_ek; ../../../../../common/services/clock; ../../../../../sam/drivers/matrix; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/components/memory/nand_flash/nand_flash_ebi; ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../common/services/gpio; ../../../../../common/services/storage/ecc_hamming; ../../../../../common/services/serial/sam_uart; ../../../../../common/services/delay; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_spare_scheme.c nand_flash_model.c nand_flash_raw_smc.c nand_flash_common.h nand_flash_spare_scheme.h nand_flash_ecc.h nand_flash_raw.h nand_flash_model.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c nand_flash_translation.h nand_flash_mem.h nand_flash_management.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm3.a
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx.h at45dbx_hal_spi.h at45dbx_mem.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/storage/ecc_hamming
    ../../../../../common/services/storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/matrix
    ../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/ebi/smc
    ../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/boards/sam3s_ek
    ../../../../../sam/boards/sam3s_ek/: init.c led.c led.h sam3s_ek.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../sam/utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c exceptions.h system_sam3s.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../../../sam/utils/cmsis/sam3s/include/: sam3s1c.h sam3s2c.h sam3s4a.h sam3s2a.h sam3s1b.h sam3s1a.h sam3s4c.h sam3s.h sam3s2b.h sam3s4b.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../../../sam/utils/cmsis/sam3s/include/instance/: instance_efc.h instance_ssc.h instance_smc.h instance_pioa.h instance_pwm.h instance_spi.h instance_pioc.h instance_usart0.h instance_rtc.h instance_uart1.h instance_hsmci.h instance_dacc.h instance_tc1.h instance_udp.h instance_twi1.h instance_supc.h instance_matrix.h instance_pmc.h instance_wdt.h instance_rtt.h instance_gpbr.h instance_tc0.h instance_adc.h instance_chipid.h instance_piob.h instance_twi0.h instance_uart0.h instance_rstc.h instance_usart1.h instance_acc.h instance_crccu.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../../../sam/utils/cmsis/sam3s/include/component/: component_smc.h component_ssc.h component_rtt.h component_matrix.h component_adc.h component_twi.h component_uart.h component_wdt.h component_pmc.h component_supc.h component_spi.h component_rstc.h component_usart.h component_pdc.h component_acc.h component_udp.h component_rtc.h component_chipid.h component_tc.h component_efc.h component_hsmci.h component_dacc.h component_gpbr.h component_pwm.h component_crccu.h component_pio.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../../../sam/utils/cmsis/sam3s/include/pio/: pio_sam3s2b.h pio_sam3s1b.h pio_sam3s4b.h pio_sam3s1a.h pio_sam3s2a.h pio_sam3s1c.h pio_sam3s4a.h pio_sam3s2c.h pio_sam3s4c.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/example/sam3s4c_sam3s_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_at45dbx.h conf_access.h conf_fatfs.h conf_nf.h conf_spi_master.h
  group thirdparty/fatfs/example/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
