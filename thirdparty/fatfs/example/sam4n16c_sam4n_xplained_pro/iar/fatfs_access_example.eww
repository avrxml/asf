<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fatfs_access_example_flash.ewp</path>
	</project>
</workspace>
