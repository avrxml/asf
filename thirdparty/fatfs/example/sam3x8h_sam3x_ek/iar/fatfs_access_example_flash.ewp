# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; ARM_MATH_CM3=true; VIRTUAL_MEMORY_ENABLE; __SAM3X8H__; AT45DBX_ENABLE
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../common/services/spi/sam_spi; ../../../../../sam/drivers/dmac; ../../../../../sam/utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../../../sam/boards/sam3x_ek; ../../../fatfs-port-r0.09/sam; ../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../sam/drivers/ebi/smc; ../../../../../common/components/memory/virtual_mem; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/utils/cmsis/sam3x/include; ../../../../../sam/drivers/spi; ../..; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/components/memory/nand_flash/nand_flash_ebi; ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../common/services/gpio; ../../../../../common/services/storage/ecc_hamming; ../../../../../common/services/delay; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ..; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_raw_nfc.c nand_flash_spare_scheme.c nand_flash_model.c nand_flash_spare_scheme.h nand_flash_ecc.h nand_flash_common.h nand_flash_raw.h nand_flash_model.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c nand_flash_translation.h nand_flash_mem.h nand_flash_management.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm3.a
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx.h at45dbx_hal_spi.h at45dbx_mem.h
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/storage/ecc_hamming
    ../../../../../common/services/storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/dmac
    ../../../../../sam/drivers/dmac/: dmac.c dmac.h
  group sam/drivers/ebi/smc
    ../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../sam/utils/cmsis/sam3x/include/: sam3x8h.h sam3x4c.h sam3x8c.h sam3xa.h sam3a4c.h sam3x4e.h sam3a8c.h sam3x8e.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_gpbr.h instance_uart.h instance_pwm.h instance_rtc.h instance_supc.h instance_efc0.h instance_piob.h instance_pioa.h instance_piod.h instance_pioc.h instance_piof.h instance_dacc.h instance_twi1.h instance_usart0.h instance_efc1.h instance_usart2.h instance_spi0.h instance_tc0.h instance_trng.h instance_matrix.h instance_pmc.h instance_usart1.h instance_adc.h instance_twi0.h instance_usart3.h instance_dmac.h instance_sdramc.h instance_spi1.h instance_tc1.h instance_hsmci.h instance_can1.h instance_wdt.h instance_tc2.h instance_ssc.h instance_chipid.h instance_rstc.h instance_smc.h instance_can0.h instance_uotghs.h instance_emac.h instance_pioe.h instance_rtt.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../sam/utils/cmsis/sam3x/include/component/: component_emac.h component_pdc.h component_matrix.h component_rstc.h component_uotghs.h component_pio.h component_usart.h component_rtc.h component_hsmci.h component_uart.h component_dacc.h component_chipid.h component_trng.h component_dmac.h component_smc.h component_twi.h component_sdramc.h component_rtt.h component_ssc.h component_efc.h component_gpbr.h component_can.h component_supc.h component_tc.h component_spi.h component_pmc.h component_pwm.h component_wdt.h component_adc.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3x4e.h pio_sam3a4c.h pio_sam3a8c.h pio_sam3x8h.h pio_sam3x4c.h pio_sam3x8e.h pio_sam3x8c.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3x_ek
    ../../../../../sam/boards/sam3x_ek/: init.c led.c led.h sam3x_ek.h
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/example/sam3x8h_sam3x_ek
    ../: conf_virtual_mem.h conf_uart_serial.h conf_clock.h conf_board.h conf_at45dbx.h conf_access.h conf_fatfs.h conf_nf.h conf_spi_master.h
  group thirdparty/fatfs/example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
