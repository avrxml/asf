# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; __FREERTOS__; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../freertos-10.0.0/Source/include; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/same70/source/templates; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/same70/include; ../../../../../../sam/utils/fpu; ../../../../../../common/services/serial; ../../../../../../sam/drivers/mpu; ../../../../../../common/utils; ../..; ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM7/r0p1; ..; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/boards/same70_xplained; ../../../../../../common/services/gpio; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/same70/same70q21/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1800
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-10.0.0/Source
    ../../../../freertos-10.0.0/Source/: tasks.c timers.c stream_buffer.c croutine.c list.c queue.c event_groups.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/MemMang
    ../../../../freertos-10.0.0/Source/portable/MemMang/: heap_3.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/IAR/ARM_CM7/r0p1
    ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-10.0.0/Source/include
    ../../../../freertos-10.0.0/Source/include/: stream_buffer.h deprecated_definitions.h croutine.h message_buffer.h mpu_wrappers.h StackMacros.h portable.h queue.h stack_macros.h FreeRTOS.h list.h task.h timers.h event_groups.h projdefs.h semphr.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c
  group thirdparty/freertos/demo/sam_example/same70q21_same70_xplained
    ../: conf_uart_serial.h conf_clock.h conf_board.h FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/same70q21_same70_xplained/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70n21b.h same70.h same70q20.h same70n21.h same70j19.h same70n20b.h same70q21b.h same70j20b.h same70q20b.h same70n20.h same70j20.h same70q19b.h same70j21b.h same70j19b.h same70j21.h same70q19.h same70n19.h same70n19b.h same70q21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: pmc.h i2sc1.h smc.h i2sc0.h mcan1.h matrix.h uart3.h piod.h uart1.h usart1.h qspi.h tc1.h pioe.h acc.h piob.h hsmci.h usart2.h xdmac.h rswdt.h uart0.h tc3.h uart2.h twihs0.h gmac.h sdramc.h spi1.h usbhs.h efc.h ssc.h rtc.h chipid.h afec0.h uart4.h trng.h twihs2.h wdt.h spi0.h icm.h rstc.h utmi.h dacc.h afec1.h aes.h rtt.h mcan0.h supc.h gpbr.h pwm1.h usart0.h tc2.h isi.h pwm0.h pioa.h tc0.h twihs1.h pioc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70j20.h same70j19.h same70q21.h same70j19b.h same70q19b.h same70n21b.h same70n20.h same70q21b.h same70q20b.h same70q20.h same70j20b.h same70n19.h same70n19b.h same70q19.h same70j21.h same70n20b.h same70j21b.h same70n21.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: afec.h spi.h pio.h acc.h qspi.h hsmci.h usbhs.h chipid.h isi.h rstc.h gmac.h wdt.h smc.h rswdt.h pwm.h matrix.h utmi.h usart.h xdmac.h aes.h efc.h gpbr.h mcan.h supc.h pmc.h twihs.h rtt.h i2sc.h dacc.h uart.h rtc.h sdramc.h ssc.h icm.h trng.h tc.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../sam/boards/same70_xplained/: init.c led.h same70_xplained.h
