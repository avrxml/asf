# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC8C Atmel ATSAM4LC8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC8C__; __FREERTOS__; BOARD=SAM4L8_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM3; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../freertos-10.0.0/Source/include; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../common/services/serial; ..; ../../../../../../common/utils; ../..; ../../../../../../sam/drivers/wdt; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/flashcalw; ../../../../../../common/services/ioport; ../../../../../../sam/boards/sam4l8_xplained_pro; ../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4l/sam4l8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h dfll.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: pll.c osc.c sysclk.c dfll.c sysclk.h dfll.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../sam/utils/cmsis/sam4l/include/: sam4lc4b.h sam4lc2b.h sam4l.h sam4lc8a.h sam4lc8c.h sam4ls4c.h sam4ls8a.h sam4ls4a.h sam4lc8b.h sam4ls8c.h sam4ls2c.h sam4ls2a.h sam4lc4a.h sam4ls4b.h sam4lc2a.h sam4lc4c.h sam4lc2c.h sam4ls8b.h sam4ls2b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_bscif.h instance_aesa.h instance_adcife.h instance_picouart.h instance_freqm.h instance_parc.h instance_spi.h instance_usbc.h instance_iisc.h instance_hflashc.h instance_abdacb.h instance_eic.h instance_acifc.h instance_wdt.h instance_tc1.h instance_tc0.h instance_pm.h instance_pevc.h instance_twis0.h instance_trng.h instance_gpio.h instance_lcdca.h instance_bpm.h instance_scif.h instance_hcache.h instance_twim1.h instance_gloc.h instance_usart2.h instance_twis1.h instance_twim0.h instance_hmatrix.h instance_usart0.h instance_pdca.h instance_chipid.h instance_crccu.h instance_catb.h instance_twim2.h instance_twim3.h instance_usart3.h instance_usart1.h instance_ast.h instance_dacc.h instance_smap.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc2a.h pio_sam4lc2c.h pio_sam4lc2b.h pio_sam4ls8a.h pio_sam4ls2a.h pio_sam4ls2b.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4lc4c.h pio_sam4lc4a.h pio_sam4ls8b.h pio_sam4ls4b.h pio_sam4lc4b.h pio_sam4lc8c.h pio_sam4lc8b.h pio_sam4lc8a.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../sam/utils/cmsis/sam4l/include/component/: component_scif.h component_usart.h component_ast.h component_twim.h component_iisc.h component_parc.h component_wdt.h component_usbc.h component_gloc.h component_hmatrixb.h component_tc.h component_gpio.h component_picouart.h component_twis.h component_bscif.h component_hcache.h component_dacc.h component_lcdca.h component_flashcalw.h component_pevc.h component_acifc.h component_catb.h component_eic.h component_crccu.h component_trng.h component_chipid.h component_pdca.h component_abdacb.h component_smap.h component_adcife.h component_bpm.h component_freqm.h component_aesa.h component_pm.h component_spi.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/bpm
    ../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/boards/sam4l8_xplained_pro
    ../../../../../../sam/boards/sam4l8_xplained_pro/: init.c sam4l8_xplained_pro.h led.h
  group thirdparty/freertos/freertos-10.0.0/Source
    ../../../../freertos-10.0.0/Source/: tasks.c timers.c stream_buffer.c croutine.c list.c queue.c event_groups.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/MemMang
    ../../../../freertos-10.0.0/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/IAR/ARM_CM3
    ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-10.0.0/Source/include
    ../../../../freertos-10.0.0/Source/include/: stream_buffer.h message_buffer.h StackMacros.h portable.h task.h FreeRTOS.h list.h timers.h stack_macros.h queue.h event_groups.h croutine.h deprecated_definitions.h projdefs.h mpu_wrappers.h semphr.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c
  group thirdparty/freertos/demo/sam_example/sam4lc8c_sam4l8_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/sam4lc8c_sam4l8_xplained_pro/iar
    ./: asf.h
