# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../common/services/serial; ../../../../../../common/utils; ../..; ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/boards/sam3u_ek; ../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../common/services/gpio; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h FreeRTOS.h list.h projdefs.h mpu_wrappers.h task.h queue.h croutine.h timers.h StackMacros.h portable.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group thirdparty/freertos/demo/sam_example/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../sam/utils/cmsis/sam3u/include/: sam3u2c.h sam3u1e.h sam3u4e.h sam3u4c.h sam3u2e.h sam3u.h sam3u1c.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_usart2.h instance_usart0.h instance_piob.h instance_hsmci.h instance_twi0.h instance_tc0.h instance_spi.h instance_supc.h instance_smc.h instance_efc1.h instance_usart3.h instance_pwm.h instance_rtt.h instance_usart1.h instance_chipid.h instance_dmac.h instance_wdt.h instance_efc0.h instance_gpbr.h instance_ssc.h instance_adc.h instance_matrix.h instance_pmc.h instance_uart.h instance_rstc.h instance_udphs.h instance_pioc.h instance_twi1.h instance_pioa.h instance_rtc.h instance_adc12b.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../sam/utils/cmsis/sam3u/include/component/: component_matrix.h component_ssc.h component_pwm.h component_wdt.h component_spi.h component_adc.h component_efc.h component_pio.h component_smc.h component_dmac.h component_rtt.h component_udphs.h component_usart.h component_pmc.h component_gpbr.h component_hsmci.h component_supc.h component_rtc.h component_twi.h component_tc.h component_pdc.h component_rstc.h component_chipid.h component_uart.h component_adc12b.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2e.h pio_sam3u2c.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u4c.h pio_sam3u4e.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/boards/sam3u_ek
    ../../../../../../sam/boards/sam3u_ek/: init.c led.c led.h sam3u_ek.h
