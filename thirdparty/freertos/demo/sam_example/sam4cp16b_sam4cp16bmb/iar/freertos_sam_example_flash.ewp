# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; ARM_MATH_CM4=true; __SAM4CP16B_0__; BOARD=SAM4CP16BMB
  ICCARM.CCIncludePath2: ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM3; ../../../../../../common/services/serial/sam_uart; ../../../../freertos-10.0.0/Source/include; ../../../../../../sam/utils/preprocessor; ..; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4cp/source/templates; ../../../../../../sam/utils/cmsis/sam4cp/include; ../../../../../../common/services/serial; ../../../../../../sam/drivers/supc; ../../../../../../common/utils; ../..; ../../../../../../sam/boards/sam4cp16bmb; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4cp
    ../../../../../../common/services/clock/sam4cp/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-10.0.0/Source
    ../../../../freertos-10.0.0/Source/: tasks.c timers.c stream_buffer.c croutine.c list.c queue.c event_groups.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/MemMang
    ../../../../freertos-10.0.0/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/IAR/ARM_CM3
    ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-10.0.0/Source/include
    ../../../../freertos-10.0.0/Source/include/: stream_buffer.h message_buffer.h StackMacros.h portable.h stack_macros.h task.h FreeRTOS.h list.h timers.h queue.h event_groups.h croutine.h deprecated_definitions.h projdefs.h mpu_wrappers.h semphr.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c
  group thirdparty/freertos/demo/sam_example/sam4cp16b_sam4cp16bmb
    ../: conf_uart_serial.h conf_clock.h conf_board.h FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../sam/utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../sam/utils/cmsis/sam4cp/include/: sam4cp_0.h system_sam4cp.h sam4cp.h sam4cp16b_0.h sam4cp16b_1.h sam4cp_1.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../sam/utils/cmsis/sam4cp/include/instance/: instance_usart4.h instance_usart2.h instance_ipc1.h instance_usart0.h instance_rswdt.h instance_matrix0.h instance_smc1.h instance_icm.h instance_tc0.h instance_uart0.h instance_supc.h instance_uart1.h instance_wdt.h instance_rtc.h instance_trng.h instance_twi1.h instance_cmcc0.h instance_gpbr.h instance_spi0.h instance_rtt.h instance_slcdc.h instance_efc.h instance_rstc.h instance_adc.h instance_pioa.h instance_smc0.h instance_piob.h instance_usart3.h instance_pwm.h instance_spi1.h instance_ipc0.h instance_usart1.h instance_matrix1.h instance_aes.h instance_chipid.h instance_pioc.h instance_tc1.h instance_cmcc1.h instance_pmc.h instance_twi0.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../sam/utils/cmsis/sam4cp/include/component/: component_supc.h component_rtc.h component_adc.h component_chipid.h component_pdc.h component_tc.h component_pio.h component_usart.h component_smc.h component_gpbr.h component_ipc.h component_spi.h component_icm.h component_aes.h component_twi.h component_matrix.h component_efc.h component_slcdc.h component_cmcc.h component_trng.h component_uart.h component_wdt.h component_rtt.h component_rstc.h component_rswdt.h component_pwm.h component_pmc.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../sam/utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4cp16bmb
    ../../../../../../sam/boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
