<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_sam_example_flash.ewp</path>
	</project>
</workspace>
