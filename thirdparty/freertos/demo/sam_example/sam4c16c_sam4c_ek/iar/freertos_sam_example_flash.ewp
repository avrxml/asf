# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; ARM_MATH_CM4=true; __SAM4C16C_0__; BOARD=SAM4C_EK
  ICCARM.CCIncludePath2: ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../sam/utils/cmsis/sam4c/include; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/sam4c/source/templates; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/boards/sam4c_ek; ../../../../../../common/utils; ../..; ..; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/boards/sam4c_ek
    ../../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../sam/utils/cmsis/sam4c/include/: sam4c.h system_sam4c.h sam4c32e_0.h sam4c16c_1.h sam4c32c_1.h sam4c16c_0.h sam4c8c_1.h sam4c8c_0.h sam4c32e_1.h sam4c32c_0.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../sam/utils/cmsis/sam4c/include/component/: component_pmc.h component_pdc.h component_wdt.h component_twi.h component_matrix.h component_icm.h component_uart.h component_rtc.h component_aes.h component_ipc.h component_usart.h component_rswdt.h component_smc.h component_spi.h component_trng.h component_pio.h component_chipid.h component_tc.h component_uotghs.h component_efc.h component_pwm.h component_slcdc.h component_cmcc.h component_adc.h component_rtt.h component_rstc.h component_supc.h component_gpbr.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_uart0.h instance_twi1.h instance_efc.h instance_smc1.h instance_pwm.h instance_slcdc.h instance_chipid.h instance_tc1.h instance_cmcc0.h instance_rswdt.h instance_wdt.h instance_rtt.h instance_uart1.h instance_pmc.h instance_rstc.h instance_smc0.h instance_spi0.h instance_piod.h instance_tc0.h instance_cmcc1.h instance_piob.h instance_icm.h instance_aes.h instance_pioa.h instance_matrix1.h instance_spi1.h instance_usart3.h instance_ipc0.h instance_rtc.h instance_usart1.h instance_usart4.h instance_pioc.h instance_efc1.h instance_trng.h instance_gpbr.h instance_supc.h instance_twi0.h instance_uotghs.h instance_adc.h instance_efc0.h instance_matrix0.h instance_ipc1.h instance_usart2.h instance_usart0.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c16c.h pio_sam4c8c.h pio_sam4c32c.h pio_sam4c32e.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h sysclk.h pll.h osc.h
  group common/services/clock/sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: tasks.c queue.c list.c timers.c croutine.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h FreeRTOS.h list.h projdefs.h mpu_wrappers.h task.h queue.h croutine.h timers.h StackMacros.h portable.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/sam4c16c_sam4c_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group thirdparty/freertos/demo/sam_example/sam4c16c_sam4c_ek/iar
    ./: asf.h
