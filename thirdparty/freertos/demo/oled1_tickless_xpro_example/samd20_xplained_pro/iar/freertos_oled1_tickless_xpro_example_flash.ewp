# IAR project freertos_oled1_tickless_xpro_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; GFX_MONO_UG_2832HSWEG04=1; BOARD=SAMD20_XPLAINED_PRO; SYSTICK_MODE; TC_ASYNC=true; GFX_MONO_LCD_HEIGHT=64; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true; __FREERTOS__; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../sam0/drivers/port; ../../../../../../common2/services/gfx_mono; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../common2/services/delay; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/sercom/usart; ../..; ../../../../../../common2/components/display/ssd1306; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/tc; ..; ../../../../freertos-8.0.1/Source/include; ../../../../../../common2/services/delay/sam0; ../../../../freertos-8.0.1/Source/portable/IAR/ARM_CM0; ../../../../../../common/boards; ../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_oled1_tickless_xpro_example_flash.bin
  ILINK.IlinkOutputFile: freertos_oled1_tickless_xpro_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/demo/oled1_tickless_xpro_example
    ../../: demotasks.c tickless.c main.c oled1.h demotasks.h documentation.h cdc.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/samd20_xplained_pro
    ../: conf_demo.h conf_spi.h conf_board.h conf_ssd1306.h FreeRTOSConfig.h conf_clocks.h conf_sysfont.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/samd20_xplained_pro/iar
    ./: asf.h
  group thirdparty/freertos/freertos-8.0.1/Source
    ../../../../freertos-8.0.1/Source/: tasks.c timers.c croutine.c queue.c event_groups.c list.c
  group thirdparty/freertos/freertos-8.0.1/Source/portable/MemMang
    ../../../../freertos-8.0.1/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-8.0.1/Source/portable/IAR/ARM_CM0
    ../../../../freertos-8.0.1/Source/portable/IAR/ARM_CM0/: port_cm0_iar.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-8.0.1/Source/include
    ../../../../freertos-8.0.1/Source/include/: projdefs.h croutine.h event_groups.h FreeRTOS.h portable.h semphr.h task.h mpu_wrappers.h list.h timers.h StackMacros.h queue.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../sam0/drivers/system/clock/clock_samd20/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom_pinout.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/tc
    ../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.c tc_interrupt.h tc.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../../../sam0/drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../../../sam0/drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start
    ../../../../../../sam0/drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../../../sam0/drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../sam0/utils/cmsis/samd20/include/: samd20g16.h samd20g14.h samd20j18.h samd20g17.h samd20j15.h samd20g15.h samd20e16.h samd20j14.h samd20j16.h samd20e14.h samd20e18.h samd20e17.h samd20g18.h samd20.h samd20e15.h samd20j17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../sam0/utils/cmsis/samd20/include/instance/: pac2.h sysctrl.h gclk.h pac0.h tc2.h dac.h tc0.h adc.h dsu.h sercom4.h rtc.h port.h tc6.h sercom2.h tc1.h pm.h nvmctrl.h sercom0.h tc3.h tc7.h sercom3.h tc4.h sercom5.h ac.h tc5.h evsys.h wdt.h sercom1.h eic.h pac1.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20j15.h samd20j18.h samd20e14.h samd20g14.h samd20e18.h samd20g17.h samd20j16.h samd20j14.h samd20g16.h samd20e17.h samd20e1f.h samd20j17.h samd20e15.h samd20g18.h samd20g15.h samd20e16.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../sam0/utils/cmsis/samd20/include/component/: wdt.h sysctrl.h sercom.h evsys.h rtc.h dac.h tc.h gclk.h dsu.h ac.h port.h eic.h adc.h pm.h pac.h nvmctrl.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: tpaste.h preprocessor.h mrecursion.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/services/gfx_mono
    ../../../../../../common2/services/gfx_mono/: gfx_mono_text.c sysfont.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_ug_2832hsweg04.c sysfont.h gfx_mono.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_generic.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
