# IAR project freertos_oled1_tickless_xpro_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; TC_ASYNC=true; GFX_MONO_LCD_HEIGHT=64; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; BOARD=SAMR30_XPLAINED_PRO; __FREERTOS__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/utils/cmsis/samr30/source; ../../../../../../common2/services/gfx_mono; ../../../../freertos-10.0.0/Source/include; ..; ../../../../../../sam0/utils/preprocessor; ../../../../../../common2/services/delay; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/drivers/port; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/sercom/usart; ../..; ../../../../../../common2/components/display/ssd1306; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../common/utils; ../../../../../../sam0/boards/samr30_xplained_pro; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/drivers/tc; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../../sam0/utils/cmsis/samr30/include; ../../../../../../common2/services/delay/sam0; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/drivers/system/clock/clock_samr30; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_oled1_tickless_xpro_example_flash.bin
  ILINK.IlinkOutputFile: freertos_oled1_tickless_xpro_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/demo/oled1_tickless_xpro_example
    ../../: demotasks.c tickless.c main.c oled1.h documentation.h demotasks.h cdc.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/samr30_xplained_pro
    ../: conf_demo.h conf_spi.h conf_board.h conf_ssd1306.h conf_clocks.h FreeRTOSConfig.h conf_sysfont.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/samr30_xplained_pro/iar
    ./: asf.h
  group thirdparty/freertos/freertos-10.0.0/Source
    ../../../../freertos-10.0.0/Source/: tasks.c list.c timers.c stream_buffer.c croutine.c queue.c event_groups.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/IAR/ARM_CM0
    ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-10.0.0/Source/portable/MemMang
    ../../../../freertos-10.0.0/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-10.0.0/Source/include
    ../../../../freertos-10.0.0/Source/include/: stream_buffer.h message_buffer.h StackMacros.h portable.h stack_macros.h task.h FreeRTOS.h list.h mpu_wrappers.h timers.h queue.h event_groups.h croutine.h deprecated_definitions.h projdefs.h semphr.h
  group common2/services/gfx_mono
    ../../../../../../common2/services/gfx_mono/: gfx_mono_text.c sysfont.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_ug_2832hsweg04.c sysfont.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_generic.h gfx_mono.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../sam0/utils/cmsis/samr30/include/: samr30.h samr30e18a.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../sam0/utils/cmsis/samr30/include/component/: tcc.h sercom.h ccl.h mclk.h mtb.h pac.h ac.h adc.h tc.h rfctrl.h pm.h usb.h wdt.h supc.h dmac.h rstc.h gclk.h eic.h evsys.h tal.h oscctrl.h dsu.h nvmctrl.h port.h rtc.h osc32kctrl.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../sam0/utils/cmsis/samr30/include/instance/: mtb.h dsu.h tc4.h nvmctrl.h rstc.h tc0.h sercom4.h rtc.h sercom0.h mclk.h ccl.h port.h tal.h dmac.h gclk.h eic.h sercom3.h tc1.h tcc2.h pm.h ac.h tcc0.h tcc1.h sercom2.h adc.h usb.h osc32kctrl.h sercom1.h rfctrl.h wdt.h evsys.h oscctrl.h pac.h sercom5.h supc.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30e18a.h samr30g18a.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h mrecursion.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../sam0/drivers/system/clock/clock_samr30/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/tc
    ../../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
