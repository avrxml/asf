# IAR project freertos_oled1_tickless_xpro_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAML22_XPLAINED_PRO_B; GFX_MONO_UG_2832HSWEG04=1; TC_ASYNC=true; GFX_MONO_LCD_HEIGHT=64; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true; __FREERTOS__; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/drivers/system/reset; ../../../../../../common2/services/gfx_mono; ../../../../freertos-10.0.0/Source/include; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/utils/cmsis/saml22/include; ../../../../../../common2/services/delay; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/drivers/port; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/sercom/usart; ../..; ../../../../../../common2/components/display/ssd1306; ../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../sam0/utils/cmsis/saml22/source; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/drivers/tc; ../../../../../../sam0/boards/saml22_xplained_pro_b; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22; ../../../../../../common/utils; ../../../../../../common2/services/delay/sam0; ..; ../../../../../../sam0/drivers/system/clock/clock_saml22; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_oled1_tickless_xpro_example_flash.bin
  ILINK.IlinkOutputFile: freertos_oled1_tickless_xpro_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/demo/oled1_tickless_xpro_example
    ../../: demotasks.c tickless.c main.c oled1.h demotasks.h documentation.h cdc.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/saml22_xplained_pro_b
    ../: conf_demo.h conf_spi.h conf_clocks.h conf_board.h conf_ssd1306.h FreeRTOSConfig.h conf_sysfont.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/saml22_xplained_pro_b/iar
    ./: asf.h
  group thirdparty/freertos/freertos-10.0.0/Source
    ../../../../freertos-10.0.0/Source/: tasks.c list.c timers.c stream_buffer.c croutine.c queue.c event_groups.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/IAR/ARM_CM0
    ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-10.0.0/Source/portable/MemMang
    ../../../../freertos-10.0.0/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-10.0.0/Source/include
    ../../../../freertos-10.0.0/Source/include/: stream_buffer.h message_buffer.h StackMacros.h portable.h stack_macros.h task.h FreeRTOS.h list.h timers.h mpu_wrappers.h queue.h event_groups.h croutine.h deprecated_definitions.h projdefs.h semphr.h
  group common2/services/gfx_mono
    ../../../../../../common2/services/gfx_mono/: gfx_mono_text.c sysfont.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_ug_2832hsweg04.c sysfont.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_generic.h gfx_mono.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../sam0/drivers/system/clock/clock_saml22/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/tc
    ../../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../sam0/utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../sam0/utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../sam0/utils/cmsis/saml22/include/: saml22g17a.h saml22j18a.h saml22j17a.h saml22n17a.h saml22j16a.h saml22n18a.h saml22g16a.h saml22.h saml22g18a.h saml22n16a.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../sam0/utils/cmsis/saml22/include/pio/: saml22j17a.h saml22g16a.h saml22n16a.h saml22n18a.h saml22j16a.h saml22g17a.h saml22j18a.h saml22n17a.h saml22g18a.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../sam0/utils/cmsis/saml22/include/instance/: adc.h rtc.h nvmctrl.h usb.h evsys.h sercom5.h tcc0.h sercom1.h pac.h port.h tc0.h tal.h mtb.h oscctrl.h aes.h slcd.h tc2.h dmac.h wdt.h pm.h ac.h sercom2.h tc3.h osc32kctrl.h mclk.h gclk.h supc.h eic.h trng.h freqm.h rstc.h ccl.h tc1.h sercom0.h sercom3.h dsu.h sercom4.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../sam0/utils/cmsis/saml22/include/component/: port.h aes.h adc.h sercom.h freqm.h rstc.h ccl.h slcd.h pm.h rtc.h ac.h osc32kctrl.h pac.h gclk.h mtb.h wdt.h trng.h tal.h tcc.h mclk.h supc.h nvmctrl.h tc.h oscctrl.h evsys.h eic.h dmac.h dsu.h usb.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h mrecursion.h stringz.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../sam0/boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
