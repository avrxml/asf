# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/header_files; ../../../../../../common/services/spi/sam_spi; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../freertos-7.3.0/source/portable/iar/sam; ../../../../../../common/services/serial; ..; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../sam/drivers/spi; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/freertos/sam; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../demo-tasks; ../../../../../../sam/boards/sam3n_ek; ../../../../../../common/services/gpio; ../..; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_spi_master.c freertos_peripheral_control.c freertos_uart_serial.c freertos_usart_serial.c freertos_peripheral_control.h freertos_peripheral_control_private.h freertos_spi_master.h freertos_uart_serial.h freertos_usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/boards/sam3n_ek
    ../../../../../../sam/boards/sam3n_ek/: init.c led.c sam3n_ek.h led.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c system_sam3n.h exceptions.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../sam/utils/cmsis/sam3n/include/: sam3n1a.h sam3n00b.h sam3n1b.h sam3n0b.h sam3n4b.h sam3n00a.h sam3n0a.h sam3n2a.h sam3n2b.h sam3n4a.h sam3n0c.h sam3n4c.h sam3n2c.h sam3n.h sam3n1c.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_usart0.h instance_usart1.h instance_spi.h instance_rtc.h instance_adc.h instance_tc1.h instance_twi0.h instance_rtt.h instance_efc.h instance_matrix.h instance_pioa.h instance_piob.h instance_twi1.h instance_tc0.h instance_wdt.h instance_dacc.h instance_chipid.h instance_uart0.h instance_pioc.h instance_pwm.h instance_rstc.h instance_gpbr.h instance_pmc.h instance_supc.h instance_uart1.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../sam/utils/cmsis/sam3n/include/component/: component_rstc.h component_adc.h component_twi.h component_spi.h component_matrix.h component_efc.h component_dacc.h component_pwm.h component_wdt.h component_gpbr.h component_pmc.h component_rtt.h component_pio.h component_supc.h component_usart.h component_tc.h component_rtc.h component_chipid.h component_pdc.h component_uart.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n00b.h pio_sam3n1c.h pio_sam3n0a.h pio_sam3n0b.h pio_sam3n4b.h pio_sam3n00a.h pio_sam3n0c.h pio_sam3n2a.h pio_sam3n2b.h pio_sam3n1a.h pio_sam3n4c.h pio_sam3n2c.h pio_sam3n1b.h pio_sam3n4a.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c demo-tasks.h FreeRTOSConfig.h partest.h
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-echo-tasks.c SPI-FLASH-task.c UART-CLI-task.c CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/demo/peripheral_control/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_sleepmgr.h conf_example.h
  group thirdparty/freertos/demo/peripheral_control/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c timers.c tasks.c list.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../freertos-7.3.0/source/include/: queue.h mpu_wrappers.h FreeRTOS_CLI.h semphr.h task.h list.h StackMacros.h portable.h timers.h projdefs.h croutine.h FreeRTOS.h
