<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_peripheral_control_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\freertos_peripheral_control_sram.ewp</path>
	</project>
</workspace>
