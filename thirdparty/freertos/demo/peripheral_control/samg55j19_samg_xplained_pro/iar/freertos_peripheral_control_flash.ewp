# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; __SAMG55J19__; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAMG55_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../demo-tasks; ../../../../freertos-10.0.0/Source/include; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/flexcom; ../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../sam/drivers/efc; ../../FreeRTOS-Plus-CLI; ../../../../../../sam/utils/fpu; ../../../../../../common/services/serial; ..; ../../../../../../sam/drivers/supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../sam/utils/cmsis/samg/samg55/source/templates; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/services/freertos/sam; ../../../../../../common/services/clock; ../../../../../../sam/drivers/matrix; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../../../../../common/services/usb; ../../../../../../sam/drivers/udp; ../..; ../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../../../sam/utils/cmsis/samg/samg55/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udd.h udi.h udc_desc.h
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_usart_serial.c freertos_peripheral_control.h freertos_peripheral_control_private.h freertos_usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h sysclk.h pll.h osc.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../sam/boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h samg55n19.h samg55j19.h samg55g19.h system_samg55.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: usart2.h spi4.h flexcom5.h pdmic0.h usart4.h efc.h rtt.h spi3.h spi7.h cmcc.h twi7.h mem2mem.h supc.h usart6.h twi1.h flexcom1.h usart0.h flexcom3.h twi3.h usart3.h usart5.h twi5.h i2sc1.h crccu.h pdmic1.h i2sc0.h matrix.h usart7.h twi6.h twi0.h flexcom0.h flexcom2.h usart1.h uhp.h tc0.h twi2.h pioa.h twi4.h spi1.h rstc.h chipid.h flexcom4.h flexcom7.h udp.h spi5.h spi2.h wdt.h piob.h gpbr.h rtc.h adc.h spi0.h pmc.h tc1.h spi6.h flexcom6.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: pmc.h flexcom.h pdc.h rtt.h rstc.h chipid.h mem2mem.h i2sc.h wdt.h gpbr.h supc.h efc.h spi.h uhp.h pdmic.h tc.h udp.h cmcc.h twi.h rtc.h crccu.h usart.h adc.h pio.h matrix.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55j18.h samg55n19.h samg55g18.h samg55j19.h samg55g19.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c demo-tasks.h FreeRTOSConfig.h partest.h
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-CLI-task.c USB-CDC-CLI-task.c CLI-commands.c USART-echo-tasks.c
  group thirdparty/freertos/demo/peripheral_control/FreeRTOS-Plus-CLI
    ../../FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c FreeRTOS_CLI.h
  group thirdparty/freertos/demo/peripheral_control/samg55j19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_usb.h conf_sleepmgr.h conf_example.h
  group thirdparty/freertos/demo/peripheral_control/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group thirdparty/freertos/freertos-10.0.0/Source
    ../../../../freertos-10.0.0/Source/: tasks.c timers.c stream_buffer.c croutine.c list.c queue.c event_groups.c
  group thirdparty/freertos/freertos-10.0.0/Source/portable/IAR/ARM_CM4F
    ../../../../freertos-10.0.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-10.0.0/Source/portable/MemMang
    ../../../../freertos-10.0.0/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-10.0.0/Source/include
    ../../../../freertos-10.0.0/Source/include/: stream_buffer.h deprecated_definitions.h StackMacros.h portable.h list.h stack_macros.h task.h FreeRTOS.h croutine.h timers.h queue.h event_groups.h message_buffer.h projdefs.h mpu_wrappers.h semphr.h
