<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_peripheral_control_flash.ewp</path>
	</project>
</workspace>
