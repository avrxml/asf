# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ..; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../sam/drivers/udphs; ../../../../../../sam/boards/sam3u_ek; ../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../common/services/usb; ../../../../../../sam/drivers/pio; ../../demo-tasks; ../../../../../../common/services/gpio; ../..; ../../../../freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pdc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udi.h udc.h udd.h udc_desc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_usart_serial.c freertos_peripheral_control.h freertos_peripheral_control_private.h freertos_uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c demo-tasks.h FreeRTOSConfig.h partest.h
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-echo-tasks.c USB-CDC-CLI-task.c CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/demo/peripheral_control/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_usb.h conf_sleepmgr.h conf_example.h
  group thirdparty/freertos/demo/peripheral_control/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c timers.c tasks.c list.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../freertos-7.3.0/source/include/: queue.h mpu_wrappers.h FreeRTOS_CLI.h task.h FreeRTOS.h list.h StackMacros.h portable.h timers.h projdefs.h semphr.h croutine.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c system_sam3u.h exceptions.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../sam/utils/cmsis/sam3u/include/: sam3u2c.h sam3u1e.h sam3u4e.h sam3u4c.h sam3u2e.h sam3u.h sam3u1c.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_usart2.h instance_usart0.h instance_piob.h instance_twi0.h instance_tc0.h instance_chipid.h instance_supc.h instance_smc.h instance_efc1.h instance_usart3.h instance_pwm.h instance_rtt.h instance_usart1.h instance_dmac.h instance_wdt.h instance_efc0.h instance_gpbr.h instance_ssc.h instance_spi.h instance_adc.h instance_matrix.h instance_hsmci.h instance_pmc.h instance_uart.h instance_rstc.h instance_udphs.h instance_pioc.h instance_twi1.h instance_pioa.h instance_rtc.h instance_adc12b.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../sam/utils/cmsis/sam3u/include/component/: component_matrix.h component_ssc.h component_wdt.h component_spi.h component_adc.h component_efc.h component_pio.h component_smc.h component_pwm.h component_dmac.h component_rtt.h component_udphs.h component_usart.h component_pmc.h component_hsmci.h component_supc.h component_rtc.h component_twi.h component_tc.h component_pdc.h component_gpbr.h component_rstc.h component_chipid.h component_uart.h component_adc12b.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2c.h pio_sam3u2e.h pio_sam3u1e.h pio_sam3u1c.h pio_sam3u4c.h pio_sam3u4e.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/udphs
    ../../../../../../sam/drivers/udphs/: udphs_device.c udphs_device.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/boards/sam3u_ek
    ../../../../../../sam/boards/sam3u_ek/: init.c led.c led.h sam3u_ek.h
