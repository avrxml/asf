# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X; UDD_ENABLE; __SAM3X8E__
  ICCARM.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ..; ../../../../freertos-7.3.0/source/portable/iar/sam; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../common/services/clock; ../../../../../../sam/drivers/pdc; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/sleepmgr; ../../../../../../common/services/usb; ../../demo-tasks; ../../../../../../common/services/twi; ../..; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/arduino_due_x; ../../../../../../sam/drivers/uotghs; ../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udd.h udi.h udc_desc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_twi_master.c freertos_peripheral_control.c freertos_uart_serial.c freertos_usart_serial.c freertos_peripheral_control.h freertos_peripheral_control_private.h freertos_uart_serial.h freertos_twi_master.h freertos_usart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/twi
    ../../../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/uotghs
    ../../../../../../sam/drivers/uotghs/: uotghs_device.c uotghs_otg.h uotghs_device.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8h.h sam3x8c.h sam3a8c.h sam3x8e.h sam3x4e.h sam3x4c.h sam3xa.h sam3a4c.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_piof.h instance_tc0.h instance_rstc.h instance_ssc.h instance_supc.h instance_adc.h instance_sdramc.h instance_piob.h instance_wdt.h instance_dacc.h instance_piod.h instance_spi0.h instance_pioa.h instance_usart1.h instance_matrix.h instance_usart3.h instance_smc.h instance_pioc.h instance_gpbr.h instance_hsmci.h instance_trng.h instance_efc0.h instance_emac.h instance_pioe.h instance_usart0.h instance_twi0.h instance_spi1.h instance_pwm.h instance_rtc.h instance_usart2.h instance_can0.h instance_twi1.h instance_uart.h instance_efc1.h instance_tc2.h instance_uotghs.h instance_tc1.h instance_chipid.h instance_rtt.h instance_pmc.h instance_dmac.h instance_can1.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../sam/utils/cmsis/sam3x/include/component/: component_ssc.h component_dmac.h component_adc.h component_gpbr.h component_rstc.h component_emac.h component_sdramc.h component_pmc.h component_usart.h component_dacc.h component_pwm.h component_hsmci.h component_pdc.h component_efc.h component_matrix.h component_twi.h component_pio.h component_uotghs.h component_can.h component_wdt.h component_uart.h component_rtt.h component_trng.h component_tc.h component_chipid.h component_rtc.h component_smc.h component_spi.h component_supc.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3a4c.h pio_sam3x4c.h pio_sam3x8e.h pio_sam3x8c.h pio_sam3x4e.h pio_sam3x8h.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/arduino_due_x
    ../../../../../../sam/boards/arduino_due_x/: init.c arduino_due_x.h
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c demo-tasks.h FreeRTOSConfig.h partest.h
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USB-CDC-CLI-task.c UART-CLI-task.c CLI-commands.c TWI-EEPROM-task.c USART-echo-tasks.c USART-CLI-task.c
  group thirdparty/freertos/demo/peripheral_control/sam3x8e_arduino_due_x
    ../: conf_clock.h conf_board.h conf_usb.h conf_sleepmgr.h conf_example.h conf_uart_serial.h
  group thirdparty/freertos/demo/peripheral_control/sam3x8e_arduino_due_x/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c list.c timers.c tasks.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../freertos-7.3.0/source/include/: queue.h StackMacros.h FreeRTOS_CLI.h task.h FreeRTOS.h list.h portable.h timers.h mpu_wrappers.h projdefs.h semphr.h croutine.h
