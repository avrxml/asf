# IAR project freertos_peripheral_control_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/preprocessor; ../../../../freertos-7.3.0/source/portable/iar/arm_cm4f; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/efc; ../../../../../../sam/utils/fpu; ../../../../../../common/services/serial; ..; ../../../../../../sam/boards/samg53_xplained_pro; ../../../../../../common/services/clock; ../../../../../../sam/drivers/supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../demo-tasks; ../..; ../../../../../../sam/utils/cmsis/samg/samg53/source/templates; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils/cmsis/samg/samg53/include; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_sram.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_sram.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/samg/samg53n19/iar/sram.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_uart_serial.c freertos_usart_serial.c freertos_peripheral_control.h freertos_peripheral_control_private.h freertos_uart_serial.h freertos_usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c list.c timers.c tasks.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm4f
    ../../../../freertos-7.3.0/source/portable/iar/arm_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../freertos-7.3.0/source/include/: croutine.h queue.h mpu_wrappers.h FreeRTOS_CLI.h task.h FreeRTOS.h list.h StackMacros.h portable.h timers.h projdefs.h semphr.h
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c demo-tasks.h FreeRTOSConfig.h partest.h
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-echo-tasks.c UART-CLI-task.c CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/demo/peripheral_control/samg53n19_samg_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group thirdparty/freertos/demo/peripheral_control/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg53/source/templates/: system_samg53.c exceptions.c system_samg53.h exceptions.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../../sam/utils/cmsis/samg/samg53/include/: samg53g19.h samg53n19.h samg53.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../../sam/utils/cmsis/samg/samg53/include/component/: component_matrix.h component_usart.h component_efc.h component_pmc.h component_twi.h component_tc.h component_chipid.h component_twihs.h component_uart.h component_adc.h component_i2sc.h component_supc.h component_rtc.h component_pdc.h component_gpbr.h component_mem2mem.h component_pio.h component_rtt.h component_wdt.h component_rstc.h component_spi.h component_pdmic.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg53/include/instance/: instance_twi1.h instance_uart0.h instance_tc0.h instance_pioa.h instance_usart.h instance_rstc.h instance_pmc.h instance_matrix.h instance_supc.h instance_pdmic1.h instance_twi0.h instance_adc.h instance_twi2.h instance_wdt.h instance_spi.h instance_rtt.h instance_piob.h instance_gpbr.h instance_tc1.h instance_efc.h instance_i2sc1.h instance_i2sc0.h instance_mem2mem.h instance_rtc.h instance_chipid.h instance_uart1.h instance_pdmic0.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/samg53_xplained_pro
    ../../../../../../sam/boards/samg53_xplained_pro/: board_init.c samg53_xplained_pro.h led.h
