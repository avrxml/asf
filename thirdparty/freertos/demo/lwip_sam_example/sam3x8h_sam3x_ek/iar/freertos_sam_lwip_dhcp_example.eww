<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_sam_lwip_dhcp_example_flash.ewp</path>
	</project>
</workspace>
