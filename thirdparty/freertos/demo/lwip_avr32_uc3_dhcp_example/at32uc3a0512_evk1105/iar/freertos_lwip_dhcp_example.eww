<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_lwip_dhcp_example.ewp</path>
	</project>
</workspace>
