<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_oled1_event_group_xpro_example_flash.ewp</path>
	</project>
</workspace>
