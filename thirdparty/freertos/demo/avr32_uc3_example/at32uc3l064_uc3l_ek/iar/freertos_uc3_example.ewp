# IAR project freertos_uc3_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x0800
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3400
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../avr32/utils/preprocessor; ../../../common/include; ../../../../../../avr32/drivers/scif; ../../../../../../avr32/drivers/tc; ../../../../../../avr32/boards/uc3l_ek; ../../../../../../common/boards; ..; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../common/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/drivers/intc; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/flashcdw; ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../freertos-7.0.0/source/include; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm_uc3l.c power_clocks_lib.c pm_uc3l.h sleep.h power_clocks_lib.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c intc.h
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/boards/uc3l_ek
    ../../../../../../avr32/boards/uc3l_ek/: led.c uc3l_ek.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group thirdparty/freertos/demo/avr32_uc3_example
    ../../: main.c FreeRTOSConfig.h documentation.h
  group thirdparty/freertos/demo/avr32_uc3_example/serial
    ../../serial/: serial.c
  group thirdparty/freertos/demo/avr32_uc3_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/avr32_uc3_example/at32uc3l064_uc3l_ek
    ../: conf_example.h
  group thirdparty/freertos/demo/avr32_uc3_example/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: BlockQ.c QPeek.c comtest.c AltBlock.c countsem.c flash.c dynamic.c flop.c recmutex.c integer.c crhook.c semtest.c crflash.c death.c AltBlckQ.c GenQTest.c AltPollQ.c PollQ.c blocktim.c AltQTest.c
  group thirdparty/freertos/demo/common/include
    ../../../common/include/: comtest.h death.h mevents.h semtest.h comtest2.h AltQTest.h AltBlock.h flop.h recmutex.h AltPollQ.h integer.h partest.h QPeek.h IntQueue.h AltBlckQ.h crflash.h countsem.h blocktim.h fileIO.h PollQ.h crhook.h print.h flash.h GenQTest.h BlockQ.h serial.h dynamic.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3/: port.c read.c write.c exception.s82 portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h FreeRTOS.h list.h task.h croutine.h timers.h StackMacros.h queue.h portable.h projdefs.h mpu_wrappers.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
