# IAR project freertos_uc3_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x0800
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xF300
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../avr32/boards/uc3c_ek; ../../../../../../avr32/utils/preprocessor; ../../../common/include; ../../../../../../avr32/drivers/scif; ../../../../../../avr32/drivers/tc; ../../../../../../common/boards; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ..; ../../../../../../avr32/utils; ../../../../../../common/utils; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/drivers/intc; ../../../../../../avr32/drivers/pm; ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../freertos-7.0.0/source/include; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: comtest.c BlockQ.c QPeek.c AltBlock.c countsem.c flash.c dynamic.c flop.c recmutex.c integer.c crhook.c semtest.c crflash.c AltBlckQ.c death.c GenQTest.c AltPollQ.c PollQ.c blocktim.c AltQTest.c
  group thirdparty/freertos/demo/common/include
    ../../../common/include/: death.h mevents.h semtest.h AltQTest.h AltBlock.h flop.h recmutex.h comtest.h AltPollQ.h integer.h partest.h QPeek.h IntQueue.h AltBlckQ.h comtest2.h crflash.h countsem.h blocktim.h fileIO.h PollQ.h crhook.h print.h flash.h GenQTest.h BlockQ.h serial.h dynamic.h
  group thirdparty/freertos/demo/avr32_uc3_example
    ../../: main.c FreeRTOSConfig.h documentation.h
  group thirdparty/freertos/demo/avr32_uc3_example/serial
    ../../serial/: serial.c
  group thirdparty/freertos/demo/avr32_uc3_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/avr32_uc3_example/at32uc3c0512c_uc3c_ek
    ../: conf_example.h
  group thirdparty/freertos/demo/avr32_uc3_example/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3/: port.c read.c write.c exception.s82 portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h FreeRTOS.h list.h task.h croutine.h timers.h StackMacros.h queue.h portable.h projdefs.h mpu_wrappers.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c intc.h
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c sleep.h power_clocks_lib.h pm_uc3c.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/boards/uc3c_ek
    ../../../../../../avr32/boards/uc3c_ek/: led.c led.h uc3c_ek.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
