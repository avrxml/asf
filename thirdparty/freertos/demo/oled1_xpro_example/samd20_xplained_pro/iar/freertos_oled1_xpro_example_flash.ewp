# IAR project freertos_oled1_xpro_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; GFX_MONO_UG_2832HSWEG04=1; BOARD=SAMD20_XPLAINED_PRO; SYSTICK_MODE; SPI_CALLBACK_MODE=true; GFX_MONO_LCD_HEIGHT=64; USART_CALLBACK_MODE=true; __FREERTOS__; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../sam0/drivers/port; ../../../../../../common2/services/gfx_mono; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../common2/services/delay; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/sercom/usart; ../../../../../../common2/components/display/ssd1306; ../../../../freertos-7.4.2/Source/include; ../..; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/utils/cmsis/samd20/include/component; ../../../../../../common2/services/delay/sam0; ../../../../../../sam0/utils/cmsis/samd20/include/pio; ../../../../freertos-7.4.2/Source/portable/IAR/ARM_CM0; ../../../../../../common/boards; ../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/utils/cmsis/samd20/include/instance; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ..; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_oled1_xpro_example_flash.bin
  ILINK.IlinkOutputFile: freertos_oled1_xpro_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/demo/oled1_xpro_example
    ../../: demotasks.c main.c oled1.h documentation.h demotasks.h cdc.h
  group thirdparty/freertos/demo/oled1_xpro_example/samd20_xplained_pro
    ../: conf_demo.h conf_spi.h conf_ssd1306.h conf_board.h FreeRTOSConfig.h conf_clocks.h conf_sysfont.h
  group thirdparty/freertos/demo/oled1_xpro_example/samd20_xplained_pro/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.4.2/Source
    ../../../../freertos-7.4.2/Source/: queue.c croutine.c list.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.4.2/Source/portable/IAR/ARM_CM0
    ../../../../freertos-7.4.2/Source/portable/IAR/ARM_CM0/: FreeRTOS_port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.4.2/Source/portable/MemMang
    ../../../../freertos-7.4.2/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-7.4.2/Source/include
    ../../../../freertos-7.4.2/Source/include/: StackMacros.h semphr.h croutine.h timers.h mpu_wrappers.h list.h projdefs.h portable.h task.h queue.h FreeRTOS.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../sam0/drivers/system/clock/clock_samd20/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom_pinout.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../sam0/utils/cmsis/samd20/include/: samd20g16.h samd20g14.h samd20j18.h samd20g17.h samd20j15.h samd20j17.h samd20e16.h samd20j14.h samd20j16.h samd20e14.h samd20g15.h samd20e17.h samd20g18.h samd20.h samd20e15.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../sam0/utils/cmsis/samd20/include/component/: component_adc.h component_pac.h component_evsys.h component_sysctrl.h component_sercom.h component_gclk.h component_tc.h component_nvmctrl.h component_ac.h component_wdt.h component_eic.h component_port.h component_pm.h component_dsu.h component_rtc.h component_dac.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../sam0/utils/cmsis/samd20/include/instance/: instance_sercom1.h instance_sysctrl.h instance_sercom5.h instance_tc6.h instance_tc0.h instance_dac.h instance_dsu.h instance_adc.h instance_nvmctrl.h instance_pac1.h instance_sercom3.h instance_rtc.h instance_tc1.h instance_tc2.h instance_eic.h instance_port.h instance_gclk.h instance_pac2.h instance_pac0.h instance_tc4.h instance_tc3.h instance_pm.h instance_ac.h instance_wdt.h instance_sercom0.h instance_sercom2.h instance_sercom4.h instance_tc7.h instance_evsys.h instance_tc5.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../sam0/utils/cmsis/samd20/include/pio/: pio_samd20g15.h pio_samd20g17.h pio_samd20g18.h pio_samd20j15.h pio_samd20j14.h pio_samd20e16.h pio_samd20e14.h pio_samd20j18.h pio_samd20j16.h pio_samd20e17.h pio_samd20e1f.h pio_samd20e15.h pio_samd20g14.h pio_samd20g16.h pio_samd20j17.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/services/gfx_mono
    ../../../../../../common2/services/gfx_mono/: gfx_mono_text.c sysfont.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_ug_2832hsweg04.c sysfont.h gfx_mono.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_generic.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
