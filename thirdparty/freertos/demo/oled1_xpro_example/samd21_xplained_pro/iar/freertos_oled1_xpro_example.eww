<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_oled1_xpro_example_flash.ewp</path>
	</project>
</workspace>
