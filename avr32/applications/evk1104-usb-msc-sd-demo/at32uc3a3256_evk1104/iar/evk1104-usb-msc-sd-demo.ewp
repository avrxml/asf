# IAR project evk1104-usb-msc-sd-demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104; AT45DBX_ENABLE; ACCESS_MEM_TO_RAM_ENABLED; SD_MMC_MCI_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder; ../../../../../common/services/serial; ../../../../drivers/usbb/_asf_v1/enum/device; ../../../../services/fs/fat; ../../../../boards; ../../../../drivers/pm; ../../../../components/display/et024006dhu; ../../../../services/usb/_asf_v1; ../../../../drivers/usbb/_asf_v1; ../../../../utils/debug; ../../../../drivers/mci/_asf_v1; ../../../../boards/evk1104; ../../../../utils; ../..; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/spi; ../../../../../common/services/clock; ../../../../../common/utils/stdio/stdio_serial; ../../enum/device; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/usbb/_asf_v1/enum; ../../../../../common/services/serial/uc3_usart; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../drivers/usart; ../../../../drivers/flashc; ../../conf; ../../../../utils/preprocessor; ../../../../services/usb/_asf_v1/class/mass_storage/host_mem; ../../../../drivers/intc; ../../../../components/memory/sd_mmc/sd_mmc_mci; ../../../../../thirdparty/newlib_addons/libs/include; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx_mem.c at45dbx.c at45dbx.h at45dbx_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/memory/sd_mmc/sd_mmc_mci
    ../../../../components/memory/sd_mmc/sd_mmc_mci/: sd_mmc_mci.c sd_mmc_mci_mem.c sd_mmc_mci.h sd_mmc_mci_mem.h
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c pm.h sleep.h power_clocks_lib.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c usb_drv.h usbb.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c usb_standard_request.h usb_device_task.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/mci/_asf_v1
    ../../../../drivers/mci/_asf_v1/: mci.c mci.h sd_mmc_cmd.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1104
    ../../../../boards/evk1104/: led.c led.h evk1104.h
  group avr32/services/fs/fat
    ../../../../services/fs/fat/: navigation.c file.c fat_unusual.c fat.c navigation.h fs_com.h file.h fat.h
  group avr32/services/usb/_asf_v1
    ../../../../services/usb/_asf_v1/: usb_ids.h
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../services/usb/_asf_v1/class/mass_storage/host_mem/: host_mem.c host_mem.h
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder/: scsi_decoder.c scsi_decoder.h
  group avr32/applications/evk1104-usb-msc-sd-demo
    ../../: mmi_task.c avr32_logo.c main.c device_mass_storage_task.c ms_key_logo.c mmi_task.h avr32_logo.h ms_key_logo.h device_mass_storage_task.h main.h
  group avr32/applications/evk1104-usb-msc-sd-demo/enum/device
    ../../enum/device/: usb_descriptors.c usb_specific_request.c usb_descriptors.h usb_specific_request.h
  group avr32/applications/evk1104-usb-msc-sd-demo/conf
    ../../conf/: conf_usart_serial.h conf_at45dbx.h conf_usb.h conf_stdio_serial.h conf_explorer.h conf_sd_mmc_mci.h conf_ebi.h conf_access.h conf_clock.h conf_et024006dhu.h
  group avr32/applications/evk1104-usb-msc-sd-demo/at32uc3a3256_evk1104/iar
    ./: asf.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group thirdparty/newlib_addons/libs/include
    ../../../../../thirdparty/newlib_addons/libs/include/: nlao_io.h nlao_usart.h nlao_exceptions.h nlao_interrupts.h nlao_cpu.h
