# IAR project evk11xx-uc3b-bootselector.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../boards/dummy; ../../../../drivers/gpio; ../../../../../common/boards; ../../../../drivers/flashc; ../../../../boards; ../../../../utils; ../../../../utils/preprocessor; ../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=DUMMY_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../linker_scripts/iar/lnkuc3b1256_bootselector.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/applications/evk11xx-uc3b-bootselector
    ../../: bootselector.c
  group avr32/applications/evk11xx-uc3b-bootselector/at32uc3b1256/iar
    ./: asf.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/dummy
    ../../../../boards/dummy/: dummy_board.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
