# IAR project uc3-a3_xplained_demo_application.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../utils/preprocessor; ../../../../../common/services/clock; ../../../../utils/debug; ../../../../drivers/tc; ../../qdebug; ../../../../../common/boards; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../boards; ../../../../utils; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/gpio; ../../../../drivers/pdca; ../../../../drivers/pm; ../../../../../common/utils; ../../../../drivers/spi; ../../../../boards/uc3_a3_xplained; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/applications/uc3_a3_xplained-demo
    ../../: libuc3a-32qt-k-8rs.r82 touch.c uc3-a3_xplained_demo.c touch_api.h uc3-a3_xplained_demo.h touch_config.h
  group avr32/applications/uc3_a3_xplained-demo/qdebug
    ../../qdebug/: QDebug.c QDebugTransport.c SPI_Master.c QDebug.h SPI_Master.h QDebugTransport.h QDebugSettings.h
  group avr32/applications/uc3_a3_xplained-demo/at32uc3a3256_uc3_a3_xplained
    ../: conf_clock.h conf_board.h
  group avr32/applications/uc3_a3_xplained-demo/at32uc3a3256_uc3_a3_xplained/iar
    ./: asf.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_a3_xplained
    ../../../../boards/uc3_a3_xplained/: led.c init.c uc3_a3_xplained.h led.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h genclk.h pll.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
