<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\uc3-a3_xplained_demo_application.ewp</path>
	</project>
</workspace>
