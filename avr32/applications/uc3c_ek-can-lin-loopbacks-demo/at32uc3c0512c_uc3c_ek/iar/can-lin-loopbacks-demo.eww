<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\can-lin-loopbacks-demo.ewp</path>
	</project>
</workspace>
