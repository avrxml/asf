# IAR project uc3-audio-player_common_base.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xD41C
  ICCAVR32.CCDefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC; ACCESS_MEM_TO_RAM_ENABLED; SD_MMC_SPI_ENABLE; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../services/audio/audio_player/ai_usb_ms; ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder; ../../../../drivers/ssc/i2s; ../../../../../thirdparty/libmad/libs/include; ../../../../services/fs/fat; ../../../../services/audio/mp3/id3; ../../../../../thirdparty/ijg/libs/jpg_ijg_without_mm/include; ../../../../drivers/ebi/sdramc; ../../../../boards; ../../../../drivers/pdca; ../../../../components/audio; ../../user_interface/gui; ../../../../drivers/pm; ../../../../services/audio/audio_mixer; ../../../../components/audio/amp/tpa6130a2; ../../../../components/display/et024006dhu; ../../../../services/usb/_asf_v1; ../../../../services/audio/audio_player; ../../../../drivers/usbb/_asf_v1; ../../../../services/usb/_asf_v1/class/mass_storage/host_mem; ../../../../services/audio/audio_player/ai_sd_mmc; ../../../../boards/evk1105; ../../../../utils; ../../../../drivers/gpio; ../../../../components/audio/codec/tlv320aic23b; ../../../../../common/utils; ../../../../services/audio/audio_player/players/mp3; ../../../../drivers/spi; ../..; ../../../../components/memory/sd_mmc/sd_mmc_spi; ../../jpg; ../../conf; ../../../../components/audio/dac/pwm_dac; ..; ../../../../components/touch/qt1081; ../../../../drivers/wdt; ../../../../drivers/usbb/_asf_v1/enum; ../../../../drivers/intc; ../../../../components/memory/sdram; ../../clocks; ../../../../drivers/abdac; ../../../../drivers/ebi/smc; ../../user_interface/controller; ../../../../../common/boards; ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../services/audio/audio_player/players; ../../../../drivers/flashc; ../../../../drivers/twi; ../../../../utils/preprocessor; ../../../../drivers/cpu/cycle_counter; ../../../../../thirdparty/dlmalloc; ../../../../../thirdparty/newlib_addons/libs/include; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/libmad/libs/at32ucr2/iar
    ../../../../../thirdparty/libmad/libs/at32ucr2/iar/: libmad-at32ucr2-speed_opt.r82
  group thirdparty/libmad/libs/include
    ../../../../../thirdparty/libmad/libs/include/: mad.h
  group thirdparty/ijg/libs/jpg_ijg_without_mm/at32ucr2/iar
    ../../../../../thirdparty/ijg/libs/jpg_ijg_without_mm/at32ucr2/iar/: libjpg_ijg_without_mm-at32ucr2-speed_opt.r82
  group thirdparty/ijg/libs/jpg_ijg_without_mm/include
    ../../../../../thirdparty/ijg/libs/jpg_ijg_without_mm/include/: jversion.h jmorecfg.h jdct.h jpeglib.h jchuff.h jerror.h jconfig.h transupp.h jdhuff.h jmemsys.h cdjpeg.h jpegint.h cderror.h jinclude.h
  group thirdparty/dlmalloc
    ../../../../../thirdparty/dlmalloc/: dlmalloc.c dlsbrk.c dlmalloc.h
  group thirdparty/dlmalloc/portable/iar/avr32_uc3
    ../../../../../thirdparty/dlmalloc/portable/iar/avr32_uc3/: syscalls.c
  group thirdparty/dlmalloc/docsrc
    ../../../../../thirdparty/dlmalloc/docsrc/: documentation.h
  group thirdparty/newlib_addons/libs/include
    ../../../../../thirdparty/newlib_addons/libs/include/: nlao_exceptions.h nlao_interrupts.h nlao_io.h nlao_cpu.h nlao_usart.h
  group avr32/services/fs/fat
    ../../../../services/fs/fat/: reader_txt.c navigation.c unicode.c file.c nav_filterlist.c fat_unusual.c fat.c play_list.c navigation.h fs_com.h file.h reader_txt.h unicode.h play_list.h nav_automatic.h nav_filterlist.h fat.h
  group avr32/services/audio/mp3/id3
    ../../../../services/audio/mp3/id3/: reader_id3.c reader_id3.h
  group avr32/services/audio/audio_mixer
    ../../../../services/audio/audio_mixer/: audio_mixer.c audio_mixer.h
  group avr32/services/audio/audio_player
    ../../../../services/audio/audio_player/: audio_interface.c audio_interface.h
  group avr32/services/audio/audio_player/ai_usb_ms
    ../../../../services/audio/audio_player/ai_usb_ms/: ai_usb_ms.c ai_usb_ms_mp3_support.c host_mass_storage_task.c ai_usb_ms.h host_mass_storage_task.h ai_usb_ms_mp3_support.h
  group avr32/services/audio/audio_player/players
    ../../../../services/audio/audio_player/players/: buff_player.c buff_player.h
  group avr32/services/audio/audio_player/players/mp3
    ../../../../services/audio/audio_player/players/mp3/: mp3_libmad_player.c mp3_libmad_player.h
  group avr32/services/audio/audio_player/ai_sd_mmc
    ../../../../services/audio/audio_player/ai_sd_mmc/: ai_sd_mmc.c
  group avr32/services/usb/_asf_v1
    ../../../../services/usb/_asf_v1/: usb_ids.h
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../services/usb/_asf_v1/class/mass_storage/host_mem/: host_mem.c host_mem.h
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder/: scsi_decoder.c scsi_decoder.h
  group avr32/drivers/ssc/i2s
    ../../../../drivers/ssc/i2s/: ssc_i2s.c ssc_i2s.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c power_clocks_lib.h sleep.h pm.h
  group avr32/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c usbb.h usb_drv.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/twi
    ../../../../drivers/twi/: twi.c twi.h
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/ebi/sdramc
    ../../../../drivers/ebi/sdramc/: sdramc.c sdramc.h
  group avr32/drivers/abdac
    ../../../../drivers/abdac/: abdac.c abdac.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../../components/memory/sd_mmc/sd_mmc_spi/: sd_mmc_spi_mem.c sd_mmc_spi.c sd_mmc_spi_mem.h sd_mmc_spi.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e
    ../../../../components/memory/sdram/mt48lc16m16a2tg7e/: mt48lc16m16a2tg7e.h
  group avr32/components/audio
    ../../../../components/audio/: audio.h
  group avr32/components/audio/amp/tpa6130a2
    ../../../../components/audio/amp/tpa6130a2/: tpa6130.c tpa6130.h
  group avr32/components/audio/codec/tlv320aic23b
    ../../../../components/audio/codec/tlv320aic23b/: tlv320aic23b.c tlv320aic23b.h
  group avr32/components/audio/dac/pwm_dac
    ../../../../components/audio/dac/pwm_dac/: pwm_dac.c pwm_dac.h
  group avr32/components/touch/qt1081
    ../../../../components/touch/qt1081/: qt1081.h
  group avr32/applications/uc3-audio-player
    ../../: usb_host_task.c usb_host_enum.c codec_mp3_task.c usb_task.c com_task.c main.c nav_automatic.c usb_host_task.h com_task.h usb_host_enum.h com_task_struct.h
  group avr32/applications/uc3-audio-player/jpg
    ../../jpg/: jmemsdram.c jdatasrc.c jpeg_decoder.h
  group avr32/applications/uc3-audio-player/user_interface/gui
    ../../user_interface/gui/: et024006dhu_gui.c sdram_loader.c sdram_loader.h gui.h
  group avr32/applications/uc3-audio-player/user_interface/controller
    ../../user_interface/controller/: joystick_controller.c controller.h
  group avr32/applications/uc3-audio-player/clocks
    ../../clocks/: clocks_fosc0_12000000_fosc1_11289600.c clocks.h
  group avr32/applications/uc3-audio-player/conf
    ../../conf/: conf_usb.h conf_pwm_dac.h conf_buff_player.h conf_dlmalloc.h conf_version.h conf_jpeg_decoder.h conf_sd_mmc_spi.h conf_audio_interface.h conf_at45dbx.h conf_audio_mixer.h conf_tlv320aic23b.h conf_access.h conf_twi.h conf_explorer.h conf_ebi.h conf_et024006dhu.h conf_tpa6130.h
  group avr32/applications/uc3-audio-player/at32uc3a0512_evk1105_mp3
    ../: conf_audio_player.h
  group avr32/applications/uc3-audio-player/at32uc3a0512_evk1105_mp3/iar
    ./: asf.h
  group avr32/applications/uc3-audio-player/docsrc
    ../../docsrc/: documentation.h documentation_mass_storage.h documentation_iar.h documentation_gcc.h
  group avr32/boards/evk1105
    ../../../../boards/evk1105/: led.c evk1105.h led.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx_mem.c at45dbx.c at45dbx_mem.h at45dbx.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
