# IAR project uc3_dsplib_demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/ssc/i2s; ../../../../boards; ../../../../drivers/pdca; ../../../../components/audio; ../../../../drivers/twim; ../../../../drivers/pm; ../../../../utils/libs/dsplib/include; ../../../../components/touch/qt60168; ../../../../components/display/et024006dhu; ../../../../utils/debug; ../../../../boards/evk1104; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/spi; ../../conf; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/abdac; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../../../components/audio/amp/tpa6130a2; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../utils/preprocessor; ../../../../drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/libs/dsplib/at32ucr2/iar
    ../../../../utils/libs/dsplib/at32ucr2/iar/: libdsp-at32ucr2-dspspeed_opt.r82
  group avr32/utils/libs/dsplib/include
    ../../../../utils/libs/dsplib/include/: dsp.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/components/audio
    ../../../../components/audio/: audio.h
  group avr32/components/audio/amp/tpa6130a2
    ../../../../components/audio/amp/tpa6130a2/: tpa6130.c tpa6130.h
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/touch/qt60168
    ../../../../components/touch/qt60168/: qt60168.c qt60168.h
  group avr32/drivers/ssc/i2s
    ../../../../drivers/ssc/i2s/: ssc_i2s.c ssc_i2s.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/abdac
    ../../../../drivers/abdac/: abdac.c abdac.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/twim
    ../../../../drivers/twim/: twim.c twim.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1104
    ../../../../boards/evk1104/: led.c led.h evk1104.h
  group avr32/applications/uc3-dsplib-demo
    ../../: gui.c dsp_process.c background_image.c dsp_sprintf.c controller_evk1104.c demo.c controller.h gui.h dsp_process.h dsp_sprintf.h background_image.h
  group avr32/applications/uc3-dsplib-demo/conf
    ../../conf/: conf_qt60168.h conf_demo.h conf_ebi.h conf_twim.h conf_tpa6130.h conf_et024006dhu.h conf_twi.h
  group avr32/applications/uc3-dsplib-demo/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
