<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\uc3_dsplib_demo.ewp</path>
	</project>
</workspace>
