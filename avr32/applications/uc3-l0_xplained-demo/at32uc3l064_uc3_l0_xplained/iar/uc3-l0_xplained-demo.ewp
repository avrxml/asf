# IAR project uc3-l0_xplained-demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/scif; ..; ../../../../boards; ../../../../drivers/pdca; ../../../../drivers/pm; ../..; ../../../../drivers/pwma; ../../../../utils/debug; ../../../../drivers/tc; ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/common; ../../../../utils; ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/include; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/flashcdw; ../../../../drivers/adcifb; ../../../../../common/boards; ../../../../drivers/usart; ../../../../../thirdparty/qtouch/qdebug; ../../../../utils/preprocessor; ../../../../boards/uc3_l0_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar
    ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar/: libuc3l-qtouch-iar.r82
  group thirdparty/qtouch/devspecific/uc3/uc3l0/common
    ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/common/: SERIAL.c SERIAL.h
  group thirdparty/qtouch/devspecific/uc3/uc3l0/include
    ../../../../../thirdparty/qtouch/devspecific/uc3/uc3l0/include/: touch_api_at32uc3l.h
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebugTransport.c QDebug_at32uc3l.c QDebug_at32uc3l.h QDebugTransport.h
  group avr32/drivers/adcifb
    ../../../../drivers/adcifb/: adcifb.c adcifb.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c sleep.h power_clocks_lib.h pm_uc3l.h
  group avr32/drivers/pwma
    ../../../../drivers/pwma/: pwma.c pwma.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/flashcdw
    ../../../../drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/applications/uc3-l0_xplained-demo
    ../../: touch.c uc3-l0_xplained_demo.c touch_config_at32uc3l.h QDebugSettings.h uc3-l0_xplained_demo.h
  group avr32/applications/uc3-l0_xplained-demo/at32uc3l064_uc3_l0_xplained
    ../: conf_clock.h conf_board.h
  group avr32/applications/uc3-l0_xplained-demo/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/boards/uc3_l0_xplained
    ../../../../boards/uc3_l0_xplained/: led.c init.c led.h uc3_l0_xplained.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h genclk.h dfll.h sysclk.h
  group common/services/clock/uc3l
    ../../../../../common/services/clock/uc3l/: osc.c sysclk.c dfll.c sysclk.h genclk.h dfll.h osc.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
