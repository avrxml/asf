<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\uc3-l0_xplained-demo.ewp</path>
	</project>
</workspace>
