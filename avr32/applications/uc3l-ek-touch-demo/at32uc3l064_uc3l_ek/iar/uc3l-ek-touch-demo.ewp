# IAR project uc3l-ek-touch-demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils; ../../../../drivers/pwma; ../../../../../common/services/delay; ../../../../utils/preprocessor; ../../../../../common/services/clock; ../../../../drivers/tc; ../../../../boards/uc3l_ek; ../../../../../common/boards; ../../../../boards; ../../../../drivers/usart; ../../../../drivers/scif; ../..; ../../../../drivers/pdca; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/gpio; ../../../../drivers/flashcdw; ../../../../drivers/pm; ../../../../../common/utils; ../../qdebug; ../../conf; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/applications/uc3l-ek-touch-demo
    ../../: demo.c uc3l-ek-touch-demo.c touch_config_at32uc3l.h touch_api_at32uc3l.h demo.h QDebugSettings.h
  group avr32/applications/uc3l-ek-touch-demo/atmel_qtouch_libraries_4.3/device_specific_libraries/32bit_avr/uc3l0/library_files
    ../../atmel_qtouch_libraries_4.3/device_specific_libraries/32bit_avr/uc3l0/library_files/: libuc3l-qtouch-iar.r82
  group avr32/applications/uc3l-ek-touch-demo/qdebug
    ../../qdebug/: qdebugtransport.c qdebug.c serial.c qdebug.h serial.h qdebugtransport.h
  group avr32/applications/uc3l-ek-touch-demo/conf
    ../../conf/: conf_clock.h
  group avr32/applications/uc3l-ek-touch-demo/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c sleep.h power_clocks_lib.h pm_uc3l.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/flashcdw
    ../../../../drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/pwma
    ../../../../drivers/pwma/: pwma.c pwma.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3l_ek
    ../../../../boards/uc3l_ek/: led.c uc3l_ek.h led.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h genclk.h dfll.h sysclk.h
  group common/services/clock/uc3l
    ../../../../../common/services/clock/uc3l/: osc.c sysclk.c dfll.c sysclk.h dfll.h osc.h genclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
