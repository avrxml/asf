<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_prox_calibrate.ewp</path>
	</project>
</workspace>
