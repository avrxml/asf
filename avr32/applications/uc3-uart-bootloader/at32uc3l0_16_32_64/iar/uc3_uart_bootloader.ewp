# IAR project uc3_uart_bootloader.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../boards/dummy; ../../../../utils/preprocessor; ../../../../../common/utils; ../../boot; ../../../../drivers/scif; ../../../../../common/boards; ../../../../drivers/usart; ../../../../boards; ../../../../utils; ../../../../drivers/cpu/cycle_counter; ../../intc; ../../../../drivers/gpio; ../..; ../../../../drivers/pm; ../../../../drivers/flashcdw; ../../conf; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=DUMMY_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkat32uc3l-isp.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c sleep.h pm_uc3l.h power_clocks_lib.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/flashcdw
    ../../../../drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/applications/uc3-uart-bootloader
    ../../: uart_dfu.c isp.c uart_dfu.h isp.h flash_api.h
  group avr32/applications/uc3-uart-bootloader/clocks
    ../../clocks/: conf_clocks.c
  group avr32/applications/uc3-uart-bootloader/intc
    ../../intc/: intc.c intc.h
  group avr32/applications/uc3-uart-bootloader/boot
    ../../boot/: boot.s82 trampoline.h boot.h
  group avr32/applications/uc3-uart-bootloader/conf
    ../../conf/: conf_isp.h conf_clocks.h conf_uart.h
  group avr32/applications/uc3-uart-bootloader/at32uc3l0_16_32_64/iar
    ./: asf.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/boards/dummy
    ../../../../boards/dummy/: dummy_board.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
