# IAR project scope-meter-and-filtering-demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../drivers/twim; ../../../../drivers/scif; ../../../../boards; ../../../../drivers/pdca; ../../../../components/touch/at42qt1060; ../../../../drivers/pm; ../../../../utils/libs/dsplib/include; ../../../../components/display/et024006dhu; ../../../../boards/uc3c_ek; ../../../../utils/debug; ../../../../drivers/tc; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/adcifa; ../../../../../common/services/delay; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../conf; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../drivers/pevc; ../../../../utils/preprocessor; ../../../../drivers/dacifb; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/libs/dsplib/at32ucr3fp/iar
    ../../../../utils/libs/dsplib/at32ucr3fp/iar/: libdsp-at32ucr3fp-dspspeed_opt.r82
  group avr32/utils/libs/dsplib/include
    ../../../../utils/libs/dsplib/include/: dsp.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/touch/at42qt1060
    ../../../../components/touch/at42qt1060/: at42qt1060.c at42qt1060.h
  group avr32/boards/uc3c_ek
    ../../../../boards/uc3c_ek/: init.c led.c uc3c_ek.h led.h
  group avr32/drivers/adcifa
    ../../../../drivers/adcifa/: adcifa.c adcifa.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/scif
    ../../../../drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c sleep.h pm_uc3c.h power_clocks_lib.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/pevc
    ../../../../drivers/pevc/: pevc.c uc3c_pevc_ids.h pevc.h
  group avr32/drivers/dacifb
    ../../../../drivers/dacifb/: dacifb.c dacifb.h
  group avr32/drivers/twim
    ../../../../drivers/twim/: twim.c twim.h
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/applications/uc3c-scope-meter-and-filtering
    ../../: gui.c controller.c adc_task.c noise_task.c sinus.c background_image.c dac_task.c filter_task.c remote_task.c main.c gui.h controller.h adc_task.h remote_task.h sinus.h noise_task.h dac_task.h background_image.h filter_task.h
  group avr32/applications/uc3c-scope-meter-and-filtering/conf
    ../../conf/: conf_demo.h conf_ebi.h conf_twim.h conf_at42qt1060.h conf_clock.h conf_board.h conf_et024006dhu.h conf_sleepmgr.h
  group avr32/applications/uc3c-scope-meter-and-filtering/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/uc3c
    ../../../../../common/services/clock/uc3c/: osc.c pll.c sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
