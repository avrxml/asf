<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\scope-meter-and-filtering-demo.ewp</path>
	</project>
</workspace>
