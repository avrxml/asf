# IAR project sensors_lightprox_visualizer.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; UDD_ENABLE; BOARD=UC3_A3_XPLAINED; CONF_STDIO_REDIRECT
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../common/services/usb/class/cdc/device; ../../../../common/services/sensors; ../../../boards; ../../../drivers/twim; ../../../drivers/usbb; ../../../drivers/pm; ../../../drivers/eic; ../../../../common/utils/stdio/stdio_usb; ../../../utils; ../../../drivers/gpio; ../../../../common/services/sleepmgr; ../../../../common/utils; ../../../../common/services/usb/class/cdc; ../../../../common/services/clock; ../conf; ../../../../common/services/usb/udc; ../../../../common/services/usb; ../../../drivers/cpu/cycle_counter; ../../../../common/services/twi; ../../../boards/uc3_a3_xplained; ../../../../common/services/delay; ../../../../common/boards; ../../../drivers/flashc; ../../../utils/preprocessor; ../../../drivers/intc; ../../../../common/services/sensors/module_config; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/eic
    ../../../drivers/eic/: eic.c eic.h
  group avr32/drivers/pm
    ../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c pm.h power_clocks_lib.h sleep.h
  group avr32/drivers/intc
    ../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/gpio
    ../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/flashc
    ../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/twim
    ../../../drivers/twim/: twim.c twim.h
  group avr32/drivers/usbb
    ../../../drivers/usbb/: usbb_device.c usbb_otg.h usbb_device.h
  group avr32/drivers/cpu/cycle_counter
    ../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_a3_xplained
    ../../../boards/uc3_a3_xplained/: init.c led.c uc3_a3_xplained.h led.h
  group avr32/utils
    ../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group avr32/utils/header_files
    ../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/applications/uc3-lightprox-visualizer/conf
    ../conf/: conf_board.h conf_usb.h conf_sleepmgr.h conf_twim.h
  group avr32/applications/uc3-lightprox-visualizer/iar
    ./: asf.h
  group common/utils
    ../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/sensors
    ../../../../common/services/sensors/: sensor.c sensor_nvram.c sensor_platform.c sensor_bus.c sensor_dev.h sensor_bus.h sensor.h sensor_nvram.h
  group common/services/sensors/drivers/invensense
    ../../../../common/services/sensors/drivers/invensense/: imu3000.c itg3200.c imu3000.h itg3200.h
  group common/services/sensors/drivers/bosch
    ../../../../common/services/sensors/drivers/bosch/: bma150.c bma020.c bma250.c bma_axis.inc.c bma220.c bma222.c bma180.c bmp.c bma150.h bma_axis.inc.h bma020.h bma180.h bmp.h bma222.h bma250.h bma220.h
  group common/services/sensors/drivers/honeywell
    ../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c hmc5883l.h
  group common/services/sensors/drivers/osram
    ../../../../common/services/sensors/drivers/osram/: sfh5712.c sfh7770.c sfh5712.h sfh7770.h
  group common/services/sensors/drivers/akm
    ../../../../common/services/sensors/drivers/akm/: ak8975.c ak8975.h
  group common/services/sensors/drivers/kionix
    ../../../../common/services/sensors/drivers/kionix/: kxtf9.c kxtf9.h
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c physics.h constants.h
  group common/services/sensors/math
    ../../../../common/services/sensors/math/: fixed_t.h precision.h fixed.h
  group common/services/sensors/module_config
    ../../../../common/services/sensors/module_config/: conf_platform.h conf_clock.h conf_sensors.h
  group common/services/usb
    ../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../common/services/usb/udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/clock
    ../../../../common/services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../common/services/clock/uc3a3_a4/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/sleepmgr
    ../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../common/services/delay/: delay.h
  group common/services/twi
    ../../../../common/services/twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../common/services/twi/uc3_twim/: twi_master.h
  group common/applications/sensors/lightprox_visualizer
    ../../../../common/applications/sensors/lightprox_visualizer/: data_visualizer.c main.c data_visualizer.h
  group common/boards
    ../../../../common/boards/: board.h
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c sensors_xplained.h xplained_headers.h
