<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_lightprox_wake.ewp</path>
	</project>
</workspace>
