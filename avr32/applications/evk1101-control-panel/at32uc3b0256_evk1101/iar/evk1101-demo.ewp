# IAR project evk1101-demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1700
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3D00
  ICCAVR32.CCDefines: BOARD=EVK1101; FREERTOS_USED; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder; ../../../../drivers/usbb/_asf_v1/enum/device; ../../../../services/usb/_asf_v1/class/hid; ../../../../components/joystick/skrhabe010; ../../../../boards; ../../actuators; ../../../../drivers/pm; ../../enum/device; ../../../../services/usb/_asf_v1; ../..; ../../../../utils/debug; ../../../../drivers/tc; ../../../../drivers/adc; ../../sensors; ../../../../boards/evk1101; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/spi; ../../conf; ../../../../drivers/cpu/cycle_counter; ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../drivers/usbb/_asf_v1/enum; ../../../../drivers/usbb/_asf_v1/enum/host; ../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../utils; ../../../../drivers/usbb/_asf_v1; ../../../../../common/boards; ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../utils/preprocessor; ../../../../services/usb/_asf_v1/class/mass_storage/host_mem; ../../../../drivers/intc; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; FREERTOS_USED; AT45DBX_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx_mem.c at45dbx.c at45dbx_mem.h at45dbx.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
  group avr32/boards/evk1101
    ../../../../boards/evk1101/: led.c led.h evk1101.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/adc
    ../../../../drivers/adc/: adc.c adc.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c usb_drv.h usbb.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_enum.c usb_host_task.c usb_host_enum.h usb_host_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c usb_standard_request.h usb_device_task.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c intc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/applications/evk1101-control-panel
    ../../: main.c device_ctrl_panel_task.c device_mass_storage_task.c FreeRTOSConfig.h device_ctrl_panel_task.h device_mass_storage_task.h
  group avr32/applications/evk1101-control-panel/enum/device
    ../../enum/device/: usb_descriptors.c usb_specific_request.c usb_specific_request.h usb_descriptors.h
  group avr32/applications/evk1101-control-panel/sensors
    ../../sensors/: s_temperature.c s_pushb.c s_joystick.c s_light.c s_accelerometer.c s_pushb.h s_temperature.h s_light.h s_joystick.h s_accelerometer.h
  group avr32/applications/evk1101-control-panel/actuators
    ../../actuators/: cpled.c cpled.h
  group avr32/applications/evk1101-control-panel/docsrc
    ../../docsrc/: documentation.h
  group avr32/applications/evk1101-control-panel/conf
    ../../conf/: conf_at45dbx.h conf_usb.h conf_access.h conf_explorer.h
  group avr32/applications/evk1101-control-panel/at32uc3b0256_evk1101/iar
    ./: asf.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/services/usb/_asf_v1
    ../../../../services/usb/_asf_v1/: usb_ids.h
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../services/usb/_asf_v1/class/mass_storage/host_mem/: host_mem.c host_mem.h
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder/: scsi_decoder.c scsi_decoder.h
  group avr32/services/usb/_asf_v1/class/hid
    ../../../../services/usb/_asf_v1/class/hid/: hid.h
  group avr32/components/joystick/skrhabe010
    ../../../../components/joystick/skrhabe010/: joystick.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/: queue.c tasks.c list.c timers.c croutine.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: port.c write.c read.c exception.s82 portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: queue.h StackMacros.h FreeRTOS.h list.h task.h timers.h croutine.h semphr.h portable.h projdefs.h mpu_wrappers.h
