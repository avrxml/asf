# IAR project sensors_prox_gesture.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; BOARD=UC3_L0_XPLAINED; CONF_STDIO_REDIRECT
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../drivers/scif; ../../../../common/services/sensors; ../../../boards; ../../../drivers/twim; ../conf; ../../../drivers/pm; ../../../drivers/eic; ../../../../common/services/serial; ../../../utils; ../../../drivers/gpio; ../../../../common/services/sleepmgr; ../../../drivers/flashcdw; ../../../../common/services/clock; ../../../../common/utils/stdio/stdio_serial; ../../../drivers/cpu/cycle_counter; ../../../../common/utils; ../../../drivers/intc; ../../../../common/services/twi; ../../../../common/services/delay; ../../../../common/services/serial/uc3_usart; ../../../../common/boards; ../../../drivers/usart; ../../../utils/preprocessor; ../../../boards/uc3_l0_xplained; ../../../../common/services/sensors/module_config; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/eic
    ../../../drivers/eic/: eic.c eic.h
  group avr32/drivers/flashcdw
    ../../../drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/pm
    ../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c pm_uc3l.h power_clocks_lib.h sleep.h
  group avr32/drivers/intc
    ../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/gpio
    ../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/twim
    ../../../drivers/twim/: twim.c twim.h
  group avr32/drivers/usart
    ../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/scif
    ../../../drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/cpu/cycle_counter
    ../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_l0_xplained
    ../../../boards/uc3_l0_xplained/: led.c init.c led.h uc3_l0_xplained.h
  group avr32/utils
    ../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group avr32/utils/header_files
    ../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/applications/uc3-prox-gesture/conf
    ../conf/: conf_usart_serial.h conf_board.h conf_sleepmgr.h conf_twim.h
  group avr32/applications/uc3-prox-gesture/iar
    ./: asf.h
  group common/services/sensors
    ../../../../common/services/sensors/: sensor.c sensor_nvram.c sensor_platform.c sensor_bus.c sensor_dev.h sensor_bus.h sensor.h sensor_nvram.h
  group common/services/sensors/drivers/bosch
    ../../../../common/services/sensors/drivers/bosch/: bma150.c bma020.c bma250.c bma_axis.inc.c bma222.c bma180.c bma220.c bmp.c bmp.h bma150.h bma_axis.inc.h bma020.h bma180.h bma222.h bma220.h bma250.h
  group common/services/sensors/drivers/invensense
    ../../../../common/services/sensors/drivers/invensense/: itg3200.c imu3000.c itg3200.h imu3000.h
  group common/services/sensors/drivers/akm
    ../../../../common/services/sensors/drivers/akm/: ak8975.c ak8975.h
  group common/services/sensors/drivers/osram
    ../../../../common/services/sensors/drivers/osram/: sfh5712.c sfh7770.c sfh7770.h sfh5712.h
  group common/services/sensors/drivers/kionix
    ../../../../common/services/sensors/drivers/kionix/: kxtf9.c kxtf9.h
  group common/services/sensors/drivers/honeywell
    ../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c hmc5883l.h
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c constants.h physics.h
  group common/services/sensors/math
    ../../../../common/services/sensors/math/: fixed_t.h precision.h fixed.h
  group common/services/sensors/module_config
    ../../../../common/services/sensors/module_config/: conf_platform.h conf_clock.h conf_sensors.h
  group common/services/clock
    ../../../../common/services/clock/: genclk.h osc.h dfll.h sysclk.h
  group common/services/clock/uc3l
    ../../../../common/services/clock/uc3l/: dfll.c sysclk.c osc.c dfll.h genclk.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/services/delay
    ../../../../common/services/delay/: delay.h
  group common/services/twi
    ../../../../common/services/twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../common/services/twi/uc3_twim/: twi_master.h
  group common/utils
    ../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../common/boards/: board.h
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c xplained_headers.h sensors_xplained.h
  group common/applications/sensors/prox_gesture
    ../../../../common/applications/sensors/prox_gesture/: main.c
