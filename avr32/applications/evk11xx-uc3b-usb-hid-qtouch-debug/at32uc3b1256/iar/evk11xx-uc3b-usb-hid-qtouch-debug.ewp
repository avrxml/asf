# IAR project evk11xx-uc3b-usb-hid-qtouch-debug.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1D00
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x4D00
  ICCAVR32.CCDefines: BOARD=USER_BOARD
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils; ../../../../services/usb/_asf_v1; ../../../../utils/preprocessor; ../../../../drivers/usbb/_asf_v1/enum/device; ../../../../drivers/usbb/_asf_v1; ../../../../../thirdparty/newlib_addons/libs/include; ../..; ../../../../../common/boards; ../../../../services/usb/_asf_v1/class/hid; ../../../../drivers/usart; ../../../../drivers/flashc; ../../conf; ../../../../drivers/pdca; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/gpio; ../../../../../common/services/fifo; ../../../../drivers/pm; ../../../../../common/utils; ../../enum/device; ../../../../drivers/intc; ../../../../drivers/usbb/_asf_v1/enum; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3b/1256/iar/lnkuc3b1256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/applications/evk11xx-uc3b-usb-hid-qtouch-debug
    ../../: qtouch_debug_frame.c led.c device_hid_qtouch_debug_task.c hid_qtouch_debug.c led.h device_hid_qtouch_debug_task.h user_board.h qtouch_debug_frame.h hid_qtouch_debug.h
  group avr32/applications/evk11xx-uc3b-usb-hid-qtouch-debug/enum/device
    ../../enum/device/: usb_specific_request.c usb_descriptors.c usb_descriptors.h usb_specific_request.h
  group avr32/applications/evk11xx-uc3b-usb-hid-qtouch-debug/conf
    ../../conf/: conf_usb.h
  group avr32/applications/evk11xx-uc3b-usb-hid-qtouch-debug/at32uc3b1256/iar
    ./: asf.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c usb_drv.h usbb.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c usb_standard_request.h usb_device_task.h
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/services/usb/_asf_v1
    ../../../../services/usb/_asf_v1/: usb_ids.h
  group avr32/services/usb/_asf_v1/class/hid
    ../../../../services/usb/_asf_v1/class/hid/: hid.h
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c fifo.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group thirdparty/newlib_addons/libs/include
    ../../../../../thirdparty/newlib_addons/libs/include/: nlao_usart.h nlao_interrupts.h nlao_io.h nlao_exceptions.h nlao_cpu.h
