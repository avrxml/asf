<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\evk11xx-uc3b-usb-hid-qtouch-debug.ewp</path>
	</project>
</workspace>
