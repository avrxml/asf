# IAR project rz600-uc3a-wireless-uart.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=RZ600; UDD_ENABLE; UDD_NO_SLEEP_MGR; EXT_BOARD=RZ600_AT86RF230B
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../common/services/usb/class/cdc/device; ../../../../../common/components/wireless; ../../../../boards; ../../../../../common/services/spi/uc3_spi; ../../../../drivers/usbb; ../../../../drivers/pm; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/rz600; ../../../../drivers/spi; ../../../../../common/services/usb/class/cdc; ../../../../../common/services/clock; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/cpu/cycle_counter; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../drivers/flashc; ../..; ../../../../utils/preprocessor; ../../../../drivers/intc; ../../conf; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../common/services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h genclk.h pll.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/components/wireless
    ../../../../../common/components/wireless/: at86rfx_driver.c at86rfx_driver.h
  group common/components/wireless/at86rf230b
    ../../../../../common/components/wireless/at86rf230b/: at86rf230b.c at86rf230b.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/usbb
    ../../../../drivers/usbb/: usbb_device.c usbb_otg.h usbb_device.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/rz600
    ../../../../boards/rz600/: led.c init.c led.h rz600.h
  group avr32/applications/rz600-uc3a-wireless-uart
    ../../: main.c main.h
  group avr32/applications/rz600-uc3a-wireless-uart/conf
    ../../conf/: conf_usb.h conf_spi_master.h conf_clock.h conf_board.h conf_at86rfx.h conf_sleepmgr.h
  group avr32/applications/rz600-uc3a-wireless-uart/at32uc3a3256s_rz600_at86rf230b/iar
    ./: asf.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
