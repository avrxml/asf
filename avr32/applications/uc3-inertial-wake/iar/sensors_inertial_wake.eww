<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_inertial_wake.ewp</path>
	</project>
</workspace>
