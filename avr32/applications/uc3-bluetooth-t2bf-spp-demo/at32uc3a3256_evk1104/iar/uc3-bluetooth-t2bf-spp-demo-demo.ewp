# IAR project uc3-bluetooth-t2bf-spp-demo-demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0xC0
  General.GCStackSize: 0x10
  General.GHeapSize: 0x462E
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../thirdparty/micrium/ucos-ii/uc-cpu; ../../../../drivers/rtc; ../../../../boards; ../../conf; ../../../../drivers/pm; ../../../../components/touch/qt60168; ../../../../components/display/et024006dhu; ../../../../utils/debug; ../../../../drivers/tc; ../../../../boards/evk1104; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../drivers/spi; ../../../../../common/services/clock; ../../user_interface/gui; ../../../../drivers/cpu/cycle_counter; ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar; ../../bsp; ../../user_interface/controller; ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/source; ../../../../../common/services/delay; ../../../../drivers/ebi/smc; ../../../../../common/boards; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../../thirdparty/cybercom/t2bf; ../../../../utils/preprocessor; ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar; ../../../../drivers/intc; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3a3256_nvram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/cybercom/t2bf
    ../../../../../thirdparty/cybercom/t2bf/: btypes.h t2bf.h unistr.h
  group thirdparty/cybercom/t2bf/iar
    ../../../../../thirdparty/cybercom/t2bf/iar/: tblue_lib.r82 t2bf_lib.r82
  group thirdparty/micrium/ucos-ii/ucos-ii/source
    ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/source/: os_tmr.c os_sem.c os_mem.c os_time.c os_core.c os_q.c os_task.c os_flag.c os_mbox.c os_mutex.c ucos_ii.h
  group thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar
    ../../../../../thirdparty/micrium/ucos-ii/ucos-ii/ports/avr32/uc3/iar/: os_dbg.c os_cpu_c.c os_cpu_a.asm os_cpu.h
  group thirdparty/micrium/ucos-ii/uc-cpu
    ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/: cpu_def.h
  group thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar
    ../../../../../thirdparty/micrium/ucos-ii/uc-cpu/avr32/uc3/iar/: cpu_a.asm cpu.h
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/touch/qt60168
    ../../../../components/touch/qt60168/: qt60168.c qt60168.h
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo
    ../../: appEngine_t2bf_atmel.c main.c appEngine_t2bf_atmel.h
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/user_interface/gui
    ../../user_interface/gui/: et024006dhu_gui.c gui.h
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/user_interface/controller
    ../../user_interface/controller/: qt60168_controller.c controller.h
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/conf
    ../../conf/: uart_config.c conf_qt60168.h includes.h conf_ebi.h conf_clock.h app_cfg.h conf_et024006dhu.h os_cfg.h
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/bsp
    ../../bsp/: bsp-evk1104.c vectors.asm bsp.h
  group avr32/applications/uc3-bluetooth-t2bf-spp-demo/at32uc3a3256_evk1104/iar
    ./: asf.h
  group avr32/boards/evk1104
    ../../../../boards/evk1104/: led.c led.h evk1104.h
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/rtc
    ../../../../drivers/rtc/: rtc.c rtc.h
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c intc.h
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/clock
    ../../../../../common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../common/boards/: board.h
