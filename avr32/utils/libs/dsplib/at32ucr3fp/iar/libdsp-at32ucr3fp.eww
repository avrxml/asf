<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libdsp-at32ucr3fp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


