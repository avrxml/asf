<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fat_example.ewp</path>
	</project>
</workspace>
