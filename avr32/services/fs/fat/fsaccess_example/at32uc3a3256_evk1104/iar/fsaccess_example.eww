<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fsaccess_example.ewp</path>
	</project>
</workspace>
