# IAR project fsaccess_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: AT45DBX_ENABLE; BOARD=EVK1100; ACCESS_MEM_TO_RAM_ENABLED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../drivers/gpio; ../../..; ../../../../../../utils/debug; ../../../../../../../common/boards; ../../../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../../../drivers/usart; ../../../../../../drivers/flashc; ../../../../../../boards; ../../../../../../utils; ../../../../../../boards/evk1100; ../../../../../../utils/preprocessor; ../../../../../../drivers/pm; ../../../../../../../common/utils; ../..; ../../../../../../drivers/spi; ../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: AT45DBX_ENABLE; BOARD=EVK1100; ACCESS_MEM_TO_RAM_ENABLED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx.c at45dbx_mem.c at45dbx.h at45dbx_mem.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group avr32/services/fs/fat
    ../../../: fat_unusual.c fsaccess.c fat.c file.c navigation.c navigation.h file.h fs_com.h fsaccess.h fat.h
  group avr32/services/fs/fat/fsaccess_example
    ../../: fsaccess_example.c conf_access.h conf_explorer.h conf_at45dbx.h
  group avr32/services/fs/fat/fsaccess_example/at32uc3a0512_evk1100/iar
    ./: asf.h
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../drivers/spi/: spi.c spi.h
  group avr32/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/evk1100
    ../../../../../../boards/evk1100/: led.c led.h evk1100.h
