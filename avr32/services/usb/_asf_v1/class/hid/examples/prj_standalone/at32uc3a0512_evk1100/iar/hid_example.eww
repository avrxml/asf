<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hid_example.ewp</path>
	</project>
</workspace>
