# IAR project example_freertos.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x3D00
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3D00
  ICCAVR32.CCDefines: BOARD=EVK1101; FREERTOS_USED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../..; ../../../../../../../../../components/joystick/skrhabe010; ../../../../../../../../../boards; ../../../../../../../../../drivers/pm; ../../../../../../../../../drivers/usbb/_asf_v1/enum/host; ../../../../../..; ../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../utils/debug; ../../../../../../../../../drivers/tc; ../../../../../../../../../drivers/adc; ../../../../../../../../../utils; ../../../../../../../../../boards/evk1101; ../../../../../../../../../drivers/gpio; ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3; ../../freertos; ../../../../host_hid; ../../../../../../../../../components/accelerometer/lis3l06al; ../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../common/utils; ../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../..; ../../../enum; ../../../conf; ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../common/boards; ../../../../../../../../../drivers/usart; ../../../../../../../../../drivers/flashc; ../../../../../../../../../utils/preprocessor; ../../../../../../../../../drivers/intc; ../../../enum/device; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; FREERTOS_USED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: timers.c tasks.c croutine.c list.c queue.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: port.c write.c read.c exception.s82 portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: semphr.h mpu_wrappers.h list.h StackMacros.h task.h queue.h croutine.h FreeRTOS.h timers.h portable.h projdefs.h
  group thirdparty/newlib_addons/libs/include
    ../../../../../../../../../../thirdparty/newlib_addons/libs/include/: nlao_interrupts.h nlao_exceptions.h nlao_usart.h nlao_io.h nlao_cpu.h
  group avr32/services/usb/_asf_v1
    ../../../../../../: usb_ids.h
  group avr32/services/usb/_asf_v1/class/hid
    ../../../../: hid.h
  group avr32/services/usb/_asf_v1/class/hid/examples
    ../../../: hid_example.c host_mouse_hid_task.c device_mouse_hid_task.c hid_example.h device_mouse_hid_task.h host_mouse_hid_task.h
  group avr32/services/usb/_asf_v1/class/hid/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c usb_descriptors.h usb_specific_request.h
  group avr32/services/usb/_asf_v1/class/hid/examples/conf
    ../../../conf/: conf_usb.h
  group avr32/services/usb/_asf_v1/class/hid/examples/prj_freertos/at32uc3b0256_evk1101/iar
    ./: asf.h
  group avr32/services/usb/_asf_v1/class/hid/examples/prj_freertos/freertos
    ../../freertos/: FreeRTOSConfig.h
  group avr32/services/usb/_asf_v1/class/hid/host_hid
    ../../../../host_hid/: host_hid.c host_hid.h
  group avr32/components/accelerometer/lis3l06al
    ../../../../../../../../../components/accelerometer/lis3l06al/: lis3l06al.c lis3l06al.h
  group avr32/components/joystick/skrhabe010
    ../../../../../../../../../components/joystick/skrhabe010/: joystick.h
  group avr32/utils
    ../../../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../../../utils/debug/: print_funcs.c debug.c print_funcs.h debug.h
  group avr32/utils/startup
    ../../../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/drivers/flashc
    ../../../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/adc
    ../../../../../../../../../drivers/adc/: adc.c adc.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c usbb.h usb_drv.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c usb_device_task.h usb_standard_request.h
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_task.c usb_host_enum.c usb_host_task.h usb_host_enum.h
  group avr32/drivers/intc
    ../../../../../../../../../drivers/intc/: intc.c intc.h
  group avr32/drivers/pm
    ../../../../../../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c pm.h power_clocks_lib.h sleep.h
  group avr32/drivers/gpio
    ../../../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/tc
    ../../../../../../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1101
    ../../../../../../../../../boards/evk1101/: led.c evk1101.h led.h
  group common/utils
    ../../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
