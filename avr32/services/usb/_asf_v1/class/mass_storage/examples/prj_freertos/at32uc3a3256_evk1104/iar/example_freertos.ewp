# IAR project example_freertos.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1800
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x9A00
  ICCAVR32.CCDefines: BOARD=EVK1104; SD_MMC_MCI_ENABLE; FREERTOS_USED; ACCESS_MEM_TO_RAM_ENABLED; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../enum/device; ../../../../scsi_decoder; ../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../../../../../../fs/fat; ../../../../../../../../../boards; ../../../../../../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../../../../../../drivers/pm; ../../../../../..; ../../../ushell; ../../../../../../../../../drivers/usbb/_asf_v1; ../../../../host_mem; ../../../../../../../../../drivers/tc; ../../../../../../../../../drivers/mci/_asf_v1; ../../../../../../../../../boards/evk1104; ../../../../../../../../../utils; ../../../../../../../../../drivers/gpio; ../../../../../../../../../../common/utils; ../../../../../../../../../drivers/spi; ../../freertos; ../../../enum; ../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../../../../../../../../drivers/usbb/_asf_v1/enum/host; ../../..; ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../conf; ../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../common/boards; ../../../virtual_mem; ../../../../../../../../../drivers/usart; ../../../../../../../../../drivers/flashc; ../../../../../../../../../utils/preprocessor; ../../../../../../../../../utils/debug; ../../../../../../../../../drivers/intc; ../../../../../../../../../components/memory/sd_mmc/sd_mmc_mci; ../../../../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/usb/_asf_v1
    ../../../../../../: usb_ids.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples
    ../../../: host_mass_storage_task.c mass_storage_example.c device_mass_storage_task.c host_mass_storage_task.h mass_storage_example.h device_mass_storage_task.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples/virtual_mem
    ../../../virtual_mem/: virtual_mem.c virtual_mem.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c usb_descriptors.h usb_specific_request.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples/ushell
    ../../../ushell/: ushell_task.c ushell_task.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples/conf
    ../../../conf/: conf_access.h conf_at45dbx.h conf_usb.h conf_explorer.h conf_sd_mmc_mci.h conf_sd_mmc_spi.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples/prj_freertos/at32uc3a3256_evk1104/iar
    ./: asf.h
  group avr32/services/usb/_asf_v1/class/mass_storage/examples/prj_freertos/freertos
    ../../freertos/: FreeRTOSConfig.h
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../host_mem/: host_mem.c host_mem.h
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../scsi_decoder/: scsi_decoder.c scsi_decoder.h
  group avr32/services/fs/fat
    ../../../../../../../../fs/fat/: fat.c navigation.c file.c fat_unusual.c fs_com.h fat.h navigation.h file.h
  group avr32/utils
    ../../../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../utils/preprocessor/: preprocessor.h tpaste.h mrepeat.h stringz.h
  group avr32/utils/header_files
    ../../../../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/components/memory/sd_mmc/sd_mmc_mci
    ../../../../../../../../../components/memory/sd_mmc/sd_mmc_mci/: sd_mmc_mci_mem.c sd_mmc_mci.c sd_mmc_mci_mem.h sd_mmc_mci.h
  group avr32/drivers/flashc
    ../../../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c usbb.h usb_drv.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_task.c usb_host_enum.c usb_host_task.h usb_host_enum.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c usb_device_task.h usb_standard_request.h
  group avr32/drivers/intc
    ../../../../../../../../../drivers/intc/: intc.c intc.h
  group avr32/drivers/pm
    ../../../../../../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/mci/_asf_v1
    ../../../../../../../../../drivers/mci/_asf_v1/: mci.c sd_mmc_cmd.h mci.h
  group avr32/drivers/usart
    ../../../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/tc
    ../../../../../../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1104
    ../../../../../../../../../boards/evk1104/: led.c evk1104.h led.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: list.c timers.c croutine.c queue.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: port.c read.c write.c exception.s82 portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: semphr.h list.h StackMacros.h task.h queue.h croutine.h FreeRTOS.h mpu_wrappers.h timers.h portable.h projdefs.h
  group thirdparty/newlib_addons/libs/include
    ../../../../../../../../../../thirdparty/newlib_addons/libs/include/: nlao_exceptions.h nlao_io.h nlao_interrupts.h nlao_usart.h nlao_cpu.h
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx.c at45dbx_mem.c at45dbx.h at45dbx_mem.h
  group common/services/storage/ctrl_access
    ../../../../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/utils
    ../../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
