<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ms_example.ewp</path>
	</project>
</workspace>
