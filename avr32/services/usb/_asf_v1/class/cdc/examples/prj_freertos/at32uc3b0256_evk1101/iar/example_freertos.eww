<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_freertos.ewp</path>
	</project>
</workspace>
