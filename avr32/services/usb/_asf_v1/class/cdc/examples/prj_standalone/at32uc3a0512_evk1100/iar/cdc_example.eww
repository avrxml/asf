<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cdc_example.ewp</path>
	</project>
</workspace>
