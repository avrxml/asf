<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_synthesizer_example.ewp</path>
	</project>
</workspace>
