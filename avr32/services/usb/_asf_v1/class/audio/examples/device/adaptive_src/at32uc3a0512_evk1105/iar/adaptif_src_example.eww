<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adaptif_src_example.ewp</path>
	</project>
</workspace>
