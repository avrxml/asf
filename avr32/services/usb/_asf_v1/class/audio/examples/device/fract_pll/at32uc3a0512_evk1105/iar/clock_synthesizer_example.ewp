# IAR project clock_synthesizer_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xD000
  ICCAVR32.CCDefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../../../../../../../../../common/boards; ..; ../../../../../../../../../../boards; ../../../../../../../../../../drivers/pdca; ../../../../../../../../../../components/audio; ../..; ../../../../../../../../../../drivers/pm; ../../../../../../../../../audio/audio_mixer; ../../../user_interface/controller; ../../../../../../../../../../components/clocks/cl_cs2200-cp; ../../../../../../../../../../components/display/et024006dhu; ../../../../../../..; ../../../../../../../../../../drivers/ssc/i2s; ../../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../../utils/debug; ../../../../../../../../../../boards/evk1105; ../../../../../../../../../../utils; ../../../../../../../../../../drivers/gpio; ../../../../../../../../../../components/audio/codec/tlv320aic23b; ../../../../../../../../../../../common/utils; ../../../../../../../../../../utils/preprocessor; ../../../../../../../../../audio/audio_player/players/usb; ../../../../../../../../../../components/audio/dac/pwm_dac; ../../../../../../hid; ../../../enum/device; ../../..; ../../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../../../../../../../../../drivers/abdac; ../../../../../../../../../../drivers/ebi/smc; ../../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../components/audio/amp/tpa6130a2; ../../../../../../../../../../drivers/usart; ../../../../../../../../../../drivers/flashc; ../../../../../../../../../../drivers/twi; ../../../enum; ../../../../../../../../../../drivers/intc; ../../../../../../../../../../components/touch/qt1081; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/usb/_asf_v1
    ../../../../../../../: usb_ids.h
  group avr32/services/usb/_asf_v1/class/audio
    ../../../../../: usb_audio.h
  group avr32/services/usb/_asf_v1/class/audio/examples/device
    ../../../: device_hid_task.c audio_example.c avr32_logo.c microphone_samples.c device_audio_task.c conf_twi.h conf_ebi.h conf_tpa6130.h device_audio_task.h conf_tlv320aic23b.h audio_example.h conf_pwm_dac.h device_hid_task.h microphone_samples.h avr32_logo.h conf_et024006dhu.h conf_usb.h
  group avr32/services/usb/_asf_v1/class/audio/examples/device/user_interface/controller
    ../../../user_interface/controller/: qt1081_controller.c controller.h
  group avr32/services/usb/_asf_v1/class/audio/examples/device/enum/device
    ../../../enum/device/: usb_specific_request.c usb_descriptors.c usb_descriptors.h usb_specific_request.h
  group avr32/services/usb/_asf_v1/class/audio/examples/device/fract_pll
    ../../: conf_cs2200.h conf_audio_mixer.h
  group avr32/services/usb/_asf_v1/class/audio/examples/device/fract_pll/at32uc3a0512_evk1105
    ../: conf_audio_player.h
  group avr32/services/usb/_asf_v1/class/audio/examples/device/fract_pll/at32uc3a0512_evk1105/iar
    ./: asf.h
  group avr32/services/usb/_asf_v1/class/hid
    ../../../../../../hid/: hid.h
  group avr32/services/audio/audio_player/players/usb
    ../../../../../../../../../audio/audio_player/players/usb/: usb_stream_player_with_cs2200.c usb_stream_player.h
  group avr32/services/audio/audio_mixer
    ../../../../../../../../../audio/audio_mixer/: audio_mixer.c audio_mixer.h
  group avr32/utils
    ../../../../../../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../../../../../utils/debug/: print_funcs.c debug.c debug.h print_funcs.h
  group avr32/utils/startup
    ../../../../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/drivers/pdca
    ../../../../../../../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/usart
    ../../../../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c usbb.h usb_drv.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c usb_device_task.h usb_standard_request.h
  group avr32/drivers/pm
    ../../../../../../../../../../drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c pm.h sleep.h power_clocks_lib.h
  group avr32/drivers/abdac
    ../../../../../../../../../../drivers/abdac/: abdac.c abdac.h
  group avr32/drivers/gpio
    ../../../../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/twi
    ../../../../../../../../../../drivers/twi/: twi.c twi.h
  group avr32/drivers/ssc/i2s
    ../../../../../../../../../../drivers/ssc/i2s/: ssc_i2s.c ssc_i2s.h
  group avr32/drivers/ebi/smc
    ../../../../../../../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/components/audio
    ../../../../../../../../../../components/audio/: audio.h
  group avr32/components/audio/codec/tlv320aic23b
    ../../../../../../../../../../components/audio/codec/tlv320aic23b/: tlv320aic23b_with_cs2200.c tlv320aic23b.h
  group avr32/components/audio/dac/pwm_dac
    ../../../../../../../../../../components/audio/dac/pwm_dac/: pwm_dac.c pwm_dac.h
  group avr32/components/audio/amp/tpa6130a2
    ../../../../../../../../../../components/audio/amp/tpa6130a2/: tpa6130.c tpa6130.h
  group avr32/components/display/et024006dhu
    ../../../../../../../../../../components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/components/clocks/cl_cs2200-cp
    ../../../../../../../../../../components/clocks/cl_cs2200-cp/: cs2200.c cs2200.h
  group avr32/components/touch/qt1081
    ../../../../../../../../../../components/touch/qt1081/: qt1081.h
  group avr32/boards/evk1105
    ../../../../../../../../../../boards/evk1105/: led.c led.h evk1105.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: read.c write.c
  group thirdparty/newlib_addons/libs/include
    ../../../../../../../../../../../thirdparty/newlib_addons/libs/include/: nlao_io.h nlao_exceptions.h nlao_cpu.h nlao_usart.h nlao_interrupts.h
  group common/utils
    ../../../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../../../../common/boards/: board.h
