<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\add_del_example.ewp</path>
	</project>
</workspace>
