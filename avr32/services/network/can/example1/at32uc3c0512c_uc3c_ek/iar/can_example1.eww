<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\can_example1.ewp</path>
	</project>
</workspace>
