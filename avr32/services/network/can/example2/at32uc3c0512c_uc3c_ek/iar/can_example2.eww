<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\can_example2.ewp</path>
	</project>
</workspace>
