<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\lin_example.ewp</path>
	</project>
</workspace>
