<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_lms.ewp</path>
	</project>
</workspace>
