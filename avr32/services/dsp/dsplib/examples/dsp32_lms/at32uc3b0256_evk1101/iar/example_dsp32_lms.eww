<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_lms.ewp</path>
	</project>
</workspace>
