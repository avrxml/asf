<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_iirpart.ewp</path>
	</project>
</workspace>
