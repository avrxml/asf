<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_complex_fft.ewp</path>
	</project>
</workspace>
