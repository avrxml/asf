<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_adpcm.ewp</path>
	</project>
</workspace>
