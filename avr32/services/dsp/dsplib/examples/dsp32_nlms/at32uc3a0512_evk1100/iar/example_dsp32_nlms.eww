<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_nlms.ewp</path>
	</project>
</workspace>
