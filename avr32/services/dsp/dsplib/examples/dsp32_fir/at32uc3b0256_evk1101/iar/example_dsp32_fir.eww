<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_fir.ewp</path>
	</project>
</workspace>
