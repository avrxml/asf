<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_adpcm_wav_player.ewp</path>
	</project>
</workspace>
