<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_signal_generation.ewp</path>
	</project>
</workspace>
