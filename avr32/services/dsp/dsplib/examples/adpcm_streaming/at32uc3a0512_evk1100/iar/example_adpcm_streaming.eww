<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_adpcm_streaming.ewp</path>
	</project>
</workspace>
