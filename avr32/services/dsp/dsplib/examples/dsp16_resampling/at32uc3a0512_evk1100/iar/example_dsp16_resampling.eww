<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_resampling.ewp</path>
	</project>
</workspace>
