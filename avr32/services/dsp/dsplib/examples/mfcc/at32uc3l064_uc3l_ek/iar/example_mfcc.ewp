# IAR project example_mfcc.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DSP_TRANSFORMS; DSP_VECTORS; DSP_OPERATORS; DSP_OPTIMIZATION=DSP_OPTI_SPEED; DSP_WINDOWING; BOARD=UC3L_EK; DSP_SIGNAL_GENERATION
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils/scripts/resampling_coefficients_generation/docsrc; ../../../../../../../drivers/scif; ../../../../utils/programs/adpcm_encode/docsrc; ../../../../utils/scripts/adpcm_encoder/docsrc; ../../../../utils/scripts/print_complex_vect/docsrc; ../../../../../../../boards; ../../../../utils/programs/data_get/docsrc; ../../../../../../../boards/uc3l_ek; ../../../../../../../drivers/pm; ../../../../utils/scripts/twiddle_factors_generator/docsrc; ../../../../generic/basic/transforms; ../../../../include; ../../../../../../../utils; ../../../../../../../drivers/gpio; ../../../../../../../drivers/flashcdw; ../../../../at32uc; ../../../../utils/programs/adpcm_streaming/docsrc; ../..; ../../../../../../../drivers/cpu/cycle_counter; ../../../../utils/scripts/print_real_vect/docsrc; ../../../../../../../../common/utils; ../../../../utils/programs/data_print/docsrc; ../../../../utils/programs/data_extract/docsrc; ../../../../utils/scripts/benchmark/docsrc; ../../../../../../../../common/boards; ../../../../utils/scripts/serial_scope/docsrc; ../../../../../../../utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/dsp/dsplib/generic/basic/signal_generation
    ../../../../generic/basic/signal_generation/: gen_sinusoidal.c gen_noise.c gen_dirac.c gen_rectangular.c gen_step.c gen_ramp.c gen_diraccomb.c gen_cosinusoidal.c gen_sawtooth.c
  group avr32/services/dsp/dsplib/generic/basic/operators
    ../../../../generic/basic/operators/: op_dsp32_kfix_ln.c op_fix_asin.c op_fix_log2.c op_kfix_cos.c op_fix_exp.c op_fix_log10.c op_fix_sin.c op_dsp16_kfix_ln.c op_kfix_sin.c op_dsp16_fix_sqrt.c op_dsp32_fix_sqrt.c op_fix_rand.c op_fix_ln.c op_fix_pow.c
  group avr32/services/dsp/dsplib/generic/basic/vectors
    ../../../../generic/basic/vectors/: vect_dsp16_dotdiv.c vect_dsp32_intdiv.c vect_dsp32_neg.c vect_dsp16_pow.c vect_dsp32_realmul.c vect_dsp32_complex_abs.c vect_dsp32_realsub.c vect_dsp32_dotdiv.c vect_dsp16_realsub.c vect_dsp16_complex_conj.c vect_dsp16_convpart.c vect_dsp32_realdiv.c vect_dsp16_complex_sub.c vect_dsp32_complex_add.c vect_dsp16_min.c vect_dsp16_add_and_saturate.c vect_dsp32_intmul.c vect_dsp16_sub.c vect_dsp32_realadd.c vect_dsp16_complex_abs.c vect_dsp32_sub.c vect_dsp16_complex_add.c vect_dsp16_realdiv.c vect_dsp32_dotmul.c vect_dsp16_realadd.c vect_convolution.c vect_dsp16_intdiv.c vect_dsp32_pow.c vect_dsp32_add.c vect_dsp16_neg.c vect_dsp16_realmul.c vect_dsp32_min.c vect_dsp32_convpart.c vect_dsp32_add_and_saturate.c vect_dsp32_complex_sub.c vect_dsp16_max.c vect_dsp16_dotmul.c vect_dsp16_intmul.c vect_dsp16_add.c vect_dsp32_max.c
  group avr32/services/dsp/dsplib/generic/basic/windowing
    ../../../../generic/basic/windowing/: win_blackman.c win_dsp16_kaiser.c win_hann.c win_welch.c win_dsp32_kaiser.c win_rectangular.c win_bartlett.c win_gauss.c win_hamming.c win_gauss.h
  group avr32/services/dsp/dsplib/generic/basic/transforms
    ../../../../generic/basic/transforms/: trans_dsp16_complex_fft.c trans_dsp32_realcomplex_fft.c trans_dsp32_twiddle_factors.c trans_dsp16_twiddle_factors.c trans_dsp16_complex_ifft.c trans_dsp16_realcomplex_fft.c trans_dsp32_twiddle_factors.h trans_dsp16_twiddle_factors.h
  group avr32/services/dsp/dsplib/at32uc
    ../../../../at32uc/: at32uc_optim.h
  group avr32/services/dsp/dsplib/at32uc/basic/vectors
    ../../../../at32uc/basic/vectors/: vect_dsp32_realmul_at32uc.c vect_dsp32_convpart_at32uc.c vect_dsp16_realdiv_at32uc.c vect_dsp16_complex_conj_at32uc.c vect_dsp16_neg_at32uc.c vect_dsp32_neg_at32uc.c vect_dsp32_add_at32uc.c vect_dsp16_convpart_at32uc.c vect_dsp16_dotdiv_at32uc.c vect_dsp16_add_at32uc.c vect_dsp32_min_at32uc.c vect_dsp16_dotmul_at32uc.c vect_dsp32_max_at32uc.c vect_dsp16_sub_at32uc.c vect_dsp16_realmul_at32uc.c vect_dsp32_sub_at32uc.c
  group avr32/services/dsp/dsplib/at32uc/basic/transforms
    ../../../../at32uc/basic/transforms/: trans_dsp16_real_complex_fft_at32uc.c trans_dsp16_complex_fft_at32uc.c trans_dsp16_complex_ifft_at32uc.c
  group avr32/services/dsp/dsplib/at32uc/basic/operators
    ../../../../at32uc/basic/operators/: op_dsp16_ln_at32uc.c op_dsp16_sqrt_at32uc.c
  group avr32/services/dsp/dsplib/at32uc/docsrc
    ../../../../at32uc/docsrc/: at32uc_benchmark.h
  group avr32/services/dsp/dsplib/examples/mfcc
    ../../: mfcc_example.c conf_mfcc.h
  group avr32/services/dsp/dsplib/examples/mfcc/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group avr32/services/dsp/dsplib/include
    ../../../../include/: target_optim.h dsp.h dsp_transforms.h dsp_windowing.h dsp_vectors.h dsp_signal_generation.h dsp_types.h dsp_operators.h
  group avr32/services/dsp/dsplib/utils/scripts/benchmark/docsrc
    ../../../../utils/scripts/benchmark/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/serial_scope/docsrc
    ../../../../utils/scripts/serial_scope/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/print_complex_vect/docsrc
    ../../../../utils/scripts/print_complex_vect/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/twiddle_factors_generator/docsrc
    ../../../../utils/scripts/twiddle_factors_generator/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/print_real_vect/docsrc
    ../../../../utils/scripts/print_real_vect/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/adpcm_encoder/docsrc
    ../../../../utils/scripts/adpcm_encoder/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/resampling_coefficients_generation/docsrc
    ../../../../utils/scripts/resampling_coefficients_generation/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/adpcm_encode/docsrc
    ../../../../utils/programs/adpcm_encode/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/data_extract/docsrc
    ../../../../utils/programs/data_extract/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/data_print/docsrc
    ../../../../utils/programs/data_print/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/adpcm_streaming/docsrc
    ../../../../utils/programs/adpcm_streaming/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/data_get/docsrc
    ../../../../utils/programs/data_get/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/docsrc
    ../../../../docsrc/: documentation.h
  group avr32/drivers/scif
    ../../../../../../../drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c power_clocks_lib.h pm_uc3l.h sleep.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/flashcdw
    ../../../../../../../drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3l_ek
    ../../../../../../../boards/uc3l_ek/: led.c led.h uc3l_ek.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
