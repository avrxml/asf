<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_mfcc.ewp</path>
	</project>
</workspace>
