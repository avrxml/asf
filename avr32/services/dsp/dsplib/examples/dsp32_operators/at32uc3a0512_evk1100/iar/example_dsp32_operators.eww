<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_operators.ewp</path>
	</project>
</workspace>
