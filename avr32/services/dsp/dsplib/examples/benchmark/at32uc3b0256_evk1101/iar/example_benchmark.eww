<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_benchmark.ewp</path>
	</project>
</workspace>
