<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_vectors.ewp</path>
	</project>
</workspace>
