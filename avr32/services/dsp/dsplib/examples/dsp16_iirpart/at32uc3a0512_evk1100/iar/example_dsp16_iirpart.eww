<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_iirpart.ewp</path>
	</project>
</workspace>
