<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_iir.ewp</path>
	</project>
</workspace>
