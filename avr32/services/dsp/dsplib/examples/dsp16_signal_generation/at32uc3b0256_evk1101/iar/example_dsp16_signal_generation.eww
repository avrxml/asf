<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_signal_generation.ewp</path>
	</project>
</workspace>
