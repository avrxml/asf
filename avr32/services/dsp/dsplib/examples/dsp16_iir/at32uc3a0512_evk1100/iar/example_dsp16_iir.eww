<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_iir.ewp</path>
	</project>
</workspace>
