<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_complex_fft.ewp</path>
	</project>
</workspace>
