<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_operators.ewp</path>
	</project>
</workspace>
