# IAR project example_adpcm_encoder.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DSP_OPTIMIZATION=DSP_OPTI_SPEED; DSP_ADPCM; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils/scripts/resampling_coefficients_generation/docsrc; ../../../../utils/programs/adpcm_encode/docsrc; ../../../../utils/scripts/adpcm_encoder/docsrc; ../../../../utils/scripts/print_complex_vect/docsrc; ../../../../../../../boards; ../../../../../../../drivers/pdca; ../../../../utils/programs/data_get/docsrc; ../../../../../../../drivers/pm; ../../../../utils/scripts/twiddle_factors_generator/docsrc; ../../../../../../../drivers/tc; ../../../../include; ../../../../../../../drivers/adc; ../../../../../../../utils; ../../../../../../../boards/evk1100; ../../../../../../../drivers/gpio; ../../../../../../../../common/utils; ../../../../at32uc; ../../../../../../../drivers/pwm; ../../../../utils/programs/adpcm_streaming/docsrc; ../../../../utils/scripts/serial_scope/docsrc; ../../../../../../../drivers/cpu/cycle_counter; ../../../../utils/scripts/print_real_vect/docsrc; ../../../../utils/programs/data_print/docsrc; ../../../../utils/programs/data_extract/docsrc; ../../../../utils/scripts/benchmark/docsrc; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: DSP_OPTIMIZATION=DSP_OPTI_SPEED; DSP_ADPCM; BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/dsp/dsplib/generic/advanced/adpcm
    ../../../../generic/advanced/adpcm/: adpcm.c
  group avr32/services/dsp/dsplib/examples/adpcm_encoder
    ../../: adpcm_example.c
  group avr32/services/dsp/dsplib/examples/adpcm_encoder/at32uc3a0512_evk1100/iar
    ./: asf.h
  group avr32/services/dsp/dsplib/include
    ../../../../include/: target_optim.h dsp.h dsp_types.h dsp_adpcm.h
  group avr32/services/dsp/dsplib/at32uc
    ../../../../at32uc/: at32uc_optim.h
  group avr32/services/dsp/dsplib/at32uc/docsrc
    ../../../../at32uc/docsrc/: at32uc_benchmark.h
  group avr32/services/dsp/dsplib/utils/scripts/benchmark/docsrc
    ../../../../utils/scripts/benchmark/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/serial_scope/docsrc
    ../../../../utils/scripts/serial_scope/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/print_complex_vect/docsrc
    ../../../../utils/scripts/print_complex_vect/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/twiddle_factors_generator/docsrc
    ../../../../utils/scripts/twiddle_factors_generator/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/print_real_vect/docsrc
    ../../../../utils/scripts/print_real_vect/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/adpcm_encoder/docsrc
    ../../../../utils/scripts/adpcm_encoder/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/scripts/resampling_coefficients_generation/docsrc
    ../../../../utils/scripts/resampling_coefficients_generation/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/adpcm_encode/docsrc
    ../../../../utils/programs/adpcm_encode/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/data_extract/docsrc
    ../../../../utils/programs/data_extract/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/data_print/docsrc
    ../../../../utils/programs/data_print/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/adpcm_streaming/docsrc
    ../../../../utils/programs/adpcm_streaming/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/utils/programs/data_get/docsrc
    ../../../../utils/programs/data_get/docsrc/: documentation.h
  group avr32/services/dsp/dsplib/docsrc
    ../../../../docsrc/: documentation.h
  group avr32/drivers/adc
    ../../../../../../../drivers/adc/: adc.c adc.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pdca
    ../../../../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/pwm
    ../../../../../../../drivers/pwm/: pwm.c pwm.h
  group avr32/drivers/tc
    ../../../../../../../drivers/tc/: tc.c tc.h
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c power_clocks_lib.h pm.h sleep.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1100
    ../../../../../../../boards/evk1100/: led.c evk1100.h led.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
