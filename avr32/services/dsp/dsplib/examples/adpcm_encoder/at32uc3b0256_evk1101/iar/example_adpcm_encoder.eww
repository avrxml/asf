<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_adpcm_encoder.ewp</path>
	</project>
</workspace>
