<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_nlms.ewp</path>
	</project>
</workspace>
