<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp32_convolution.ewp</path>
	</project>
</workspace>
