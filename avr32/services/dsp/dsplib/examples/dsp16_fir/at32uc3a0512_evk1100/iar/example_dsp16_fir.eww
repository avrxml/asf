<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_dsp16_fir.ewp</path>
	</project>
</workspace>
