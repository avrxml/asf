<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pwm4_example.ewp</path>
	</project>
</workspace>
