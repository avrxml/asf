<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pwm_example.ewp</path>
	</project>
</workspace>
