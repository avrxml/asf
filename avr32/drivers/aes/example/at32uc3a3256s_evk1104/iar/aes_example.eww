<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_example.ewp</path>
	</project>
</workspace>
