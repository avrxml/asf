<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\hmatrix_example.ewp</path>
	</project>
</workspace>
