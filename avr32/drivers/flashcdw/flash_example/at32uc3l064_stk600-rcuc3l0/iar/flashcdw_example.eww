<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashcdw_example.ewp</path>
	</project>
</workspace>
