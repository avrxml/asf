<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eic_example2.ewp</path>
	</project>
</workspace>
