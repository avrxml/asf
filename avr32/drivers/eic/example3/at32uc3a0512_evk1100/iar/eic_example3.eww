<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eic_example3.ewp</path>
	</project>
</workspace>
