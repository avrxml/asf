<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eic_example1.ewp</path>
	</project>
</workspace>
