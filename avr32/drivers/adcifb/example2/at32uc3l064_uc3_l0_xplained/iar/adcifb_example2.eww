<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adcifb_example2.ewp</path>
	</project>
</workspace>
