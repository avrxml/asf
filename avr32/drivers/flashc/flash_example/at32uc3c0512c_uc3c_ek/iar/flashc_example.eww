<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashc_example.ewp</path>
	</project>
</workspace>
