<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pm_example1.ewp</path>
	</project>
</workspace>
