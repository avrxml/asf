<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pm_example3.ewp</path>
	</project>
</workspace>
