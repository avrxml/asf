<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pm_example2.ewp</path>
	</project>
</workspace>
