<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\acifb_example1.ewp</path>
	</project>
</workspace>
