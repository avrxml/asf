# IAR project usart_usart_example2.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils/preprocessor; ../../../../../../common/services/clock; ../../../../../boards/uc3_l0_xplained; ../../../../../../common/boards; ../../..; ../../../../../boards; ../../../../../utils; ../../../../gpio; ../../../../../../common/utils; ..; ../../../../flashcdw; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usart
    ../../../: usart.c usart.h
  group avr32/drivers/usart/usart_example2
    ../../: usart_example2.c
  group avr32/drivers/usart/usart_example2/at32uc3l064_uc3_l0_xplained
    ../: conf_clock.h conf_board.h conf_example_usart.h
  group avr32/drivers/usart/usart_example2/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group avr32/drivers/flashcdw
    ../../../../flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c gpio.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../boards/uc3_l0_xplained/: led.c init.c uc3_l0_xplained.h led.h
  group avr32/utils
    ../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h dfll.h genclk.h
  group common/services/clock/uc3l
    ../../../../../../common/services/clock/uc3l/: osc.c dfll.c sysclk.c dfll.h sysclk.h osc.h genclk.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
