<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_spi_example.ewp</path>
	</project>
</workspace>
