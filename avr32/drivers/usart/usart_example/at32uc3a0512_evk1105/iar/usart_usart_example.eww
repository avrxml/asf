<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_usart_example.ewp</path>
	</project>
</workspace>
