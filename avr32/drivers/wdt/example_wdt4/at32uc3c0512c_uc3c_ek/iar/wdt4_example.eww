<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt4_example.ewp</path>
	</project>
</workspace>
