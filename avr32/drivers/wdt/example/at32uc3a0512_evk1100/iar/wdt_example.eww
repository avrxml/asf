<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt_example.ewp</path>
	</project>
</workspace>
