# IAR project pdca_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils; ../../../../pm; ../../../../gpio; ../../../../../../common/services/clock; ../../../../../boards/uc3l_ek; ../../../../../../common/boards; ../../../../../boards; ../../../../usart; ..; ../../../../scif; ../../..; ../..; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../../../common/services/sleepmgr; ../../../../flashcdw; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/flashcdw
    ../../../../flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/pdca
    ../../../: pdca.c pdca.h
  group avr32/drivers/pdca/example
    ../../: pdca_example.c ascii_anim1.h conf_sleepmgr.h ascii_anim2.h
  group avr32/drivers/pdca/example/at32uc3l064_uc3l_ek
    ../: conf_clock.h conf_example.h
  group avr32/drivers/pdca/example/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3l.c power_clocks_lib.h pm_uc3l.h sleep.h
  group avr32/drivers/usart
    ../../../../usart/: usart.c usart.h
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3l.c scif_uc3l.h
  group avr32/boards/uc3l_ek
    ../../../../../boards/uc3l_ek/: led.c uc3l_ek.h led.h
  group avr32/utils
    ../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h dfll.h genclk.h
  group common/services/clock/uc3l
    ../../../../../../common/services/clock/uc3l/: osc.c dfll.c sysclk.c dfll.h sysclk.h osc.h genclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
