<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pdca_example.ewp</path>
	</project>
</workspace>
