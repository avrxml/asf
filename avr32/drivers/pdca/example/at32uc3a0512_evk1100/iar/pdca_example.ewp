# IAR project pdca_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils; ../../../../gpio; ../../../../../../common/services/clock; ../../../../../../common/boards; ..; ../../../../usart; ../../../../flashc; ../../../../pm; ../../../../../boards; ../../..; ../..; ../../../../../boards/evk1100; ../../../../../utils/preprocessor; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/uc3a0_a1
    ../../../../../../common/services/clock/uc3a0_a1/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c flashc.h
  group avr32/drivers/pm
    ../../../../pm/: pm.c power_clocks_lib.c pm_conf_clocks.c power_clocks_lib.h sleep.h pm.h
  group avr32/drivers/pdca
    ../../../: pdca.c pdca.h
  group avr32/drivers/pdca/example
    ../../: pdca_example.c ascii_anim1.h conf_sleepmgr.h ascii_anim2.h
  group avr32/drivers/pdca/example/at32uc3a0512_evk1100
    ../: conf_clock.h conf_example.h
  group avr32/drivers/pdca/example/at32uc3a0512_evk1100/iar
    ./: asf.h
  group avr32/drivers/usart
    ../../../../usart/: usart.c usart.h
  group avr32/boards/evk1100
    ../../../../../boards/evk1100/: led.c led.h evk1100.h
  group avr32/utils
    ../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
