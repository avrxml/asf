<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dacifb_example1.ewp</path>
	</project>
</workspace>
