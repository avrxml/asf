<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ast_example2.ewp</path>
	</project>
</workspace>
