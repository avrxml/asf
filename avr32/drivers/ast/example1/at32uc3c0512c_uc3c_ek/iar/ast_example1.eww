<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ast_example1.ewp</path>
	</project>
</workspace>
