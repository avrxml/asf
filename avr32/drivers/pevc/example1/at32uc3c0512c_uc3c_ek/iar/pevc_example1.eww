<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pevc_example1.ewp</path>
	</project>
</workspace>
