<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pevc_example3.ewp</path>
	</project>
</workspace>
