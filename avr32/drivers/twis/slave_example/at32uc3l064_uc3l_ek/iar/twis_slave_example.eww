<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twis_slave_example.ewp</path>
	</project>
</workspace>
