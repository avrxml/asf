<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twim_master_example.ewp</path>
	</project>
</workspace>
