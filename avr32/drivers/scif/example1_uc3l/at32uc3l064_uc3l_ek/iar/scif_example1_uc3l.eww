<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\scif_example1_uc3l.ewp</path>
	</project>
</workspace>
