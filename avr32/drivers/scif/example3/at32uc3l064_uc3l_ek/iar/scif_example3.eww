<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\scif_example3.ewp</path>
	</project>
</workspace>
