<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example.ewp</path>
	</project>
</workspace>
