<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\macb_example.ewp</path>
	</project>
</workspace>
