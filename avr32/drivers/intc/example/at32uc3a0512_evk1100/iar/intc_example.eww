<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\intc_example.ewp</path>
	</project>
</workspace>
