<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_example4.ewp</path>
	</project>
</workspace>
