<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_example3.ewp</path>
	</project>
</workspace>
