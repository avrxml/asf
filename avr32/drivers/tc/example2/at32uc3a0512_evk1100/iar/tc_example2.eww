<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_example2.ewp</path>
	</project>
</workspace>
