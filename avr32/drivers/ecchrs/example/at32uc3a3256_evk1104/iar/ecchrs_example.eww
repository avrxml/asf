<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ecchrs_example.ewp</path>
	</project>
</workspace>
