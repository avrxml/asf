# IAR project gpio_peripheral_bus_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../..; ../../../../../../common/boards; ../../../../../boards; ../../../../../utils; ../../../../../utils/preprocessor; ../../../../../boards/uc3l_ek; ../../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/uc3l_ek
    ../../../../../boards/uc3l_ek/: led.c uc3l_ek.h led.h
  group avr32/drivers/gpio
    ../../../: gpio.c gpio.h
  group avr32/drivers/gpio/peripheral_bus_example
    ../../: gpio_peripheral_bus_example.c
  group avr32/drivers/gpio/peripheral_bus_example/at32uc3l064_uc3l_ek
    ../: conf_gpio_peripheral_bus_example.h conf_board.h
  group avr32/drivers/gpio/peripheral_bus_example/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group avr32/utils
    ../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group common/utils
    ../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
