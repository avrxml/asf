<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\acifa_example.ewp</path>
	</project>
</workspace>
