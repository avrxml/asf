<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ssc_i2s_example.ewp</path>
	</project>
</workspace>
