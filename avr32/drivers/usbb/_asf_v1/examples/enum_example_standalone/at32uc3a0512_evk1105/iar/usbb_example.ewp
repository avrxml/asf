# IAR project usbb_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x4000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x6000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../utils/preprocessor; ../../../../../../../services/usb/_asf_v1; ../../../../enum/device; ../../..; ../../../..; ../../../../../../../utils/debug; ../../../enum; ../../../../../../../../common/boards; ../../../../../../usart; ../../../../../../flashc; ../../../../../../pm; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../cpu/cycle_counter; ../../../../../../gpio; ../../../enum/device; ../../../../enum; ../../../../../../../../common/utils; ../../../../../../intc; ../../../../enum/host; ../../../../../../../boards/evk1105; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../../../usart/: usart.c usart.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../: usb_drv.c usb_drv.h usbb.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../enum/host/: usb_host_task.c usb_host_enum.c usb_host_enum.h usb_host_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../enum/device/: usb_device_task.c usb_standard_request.c usb_device_task.h usb_standard_request.h
  group avr32/drivers/usbb/_asf_v1/examples
    ../../../: host_template_task.c enum_example.c device_template_task.c host_template_task.h device_template_task.h
  group avr32/drivers/usbb/_asf_v1/examples/enum
    ../../../enum/: conf_usb.h
  group avr32/drivers/usbb/_asf_v1/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c usb_descriptors.h usb_specific_request.h
  group avr32/drivers/usbb/_asf_v1/examples/enum_example_standalone/at32uc3a0512_evk1105/iar
    ./: asf.h
  group avr32/drivers/pm
    ../../../../../../pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/flashc
    ../../../../../../flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../../../intc/: intc.c exception.s82 intc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1105
    ../../../../../../../boards/evk1105/: led.c led.h evk1105.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/services/usb/_asf_v1
    ../../../../../../../services/usb/_asf_v1/: usb_ids.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
