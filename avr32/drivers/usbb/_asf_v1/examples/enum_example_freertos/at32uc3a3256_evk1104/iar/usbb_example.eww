<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usbb_example.ewp</path>
	</project>
</workspace>
