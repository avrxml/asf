# IAR project usbb_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x4000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x6000
  ICCAVR32.CCDefines: FREERTOS_USED; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../enum/device; ../../../../../../../boards; ../../../../../../pm; ../../../../../../../services/usb/_asf_v1; ../../../..; ../../../../../../../utils/debug; ../../../../../../tc; ../../../../../../../utils; ../../../../../../../boards/evk1100; ../../../../../../gpio; ../../../enum/device; ../../../../../../../../common/utils; ../../../enum; ../../freertos; ../../../../../../cpu/cycle_counter; ../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../enum; ../../../../enum/host; ../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../..; ../../../../../../../../common/boards; ../../../../../../usart; ../../../../../../flashc; ../../../../../../../utils/preprocessor; ../../../../../../intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: FREERTOS_USED; BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/usbb/_asf_v1
    ../../../../: usb_drv.c usb_drv.h usbb.h
  group avr32/drivers/usbb/_asf_v1/examples
    ../../../: enum_example.c device_template_task.c host_template_task.c host_template_task.h device_template_task.h
  group avr32/drivers/usbb/_asf_v1/examples/enum
    ../../../enum/: conf_usb.h
  group avr32/drivers/usbb/_asf_v1/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c usb_descriptors.h usb_specific_request.h
  group avr32/drivers/usbb/_asf_v1/examples/enum_example_freertos/at32uc3a0512_evk1100/iar
    ./: asf.h
  group avr32/drivers/usbb/_asf_v1/examples/enum_example_freertos/freertos
    ../../freertos/: FreeRTOSConfig.h
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../enum/: usb_task.c usb_task.h
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../enum/host/: usb_host_enum.c usb_host_task.c usb_host_enum.h usb_host_task.h
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../enum/device/: usb_device_task.c usb_standard_request.c usb_device_task.h usb_standard_request.h
  group avr32/drivers/intc
    ../../../../../../intc/: intc.c intc.h
  group avr32/drivers/pm
    ../../../../../../pm/: pm_conf_clocks.c power_clocks_lib.c pm.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/tc
    ../../../../../../tc/: tc.c tc.h
  group avr32/drivers/flashc
    ../../../../../../flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../../usart/: usart.c usart.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1100
    ../../../../../../../boards/evk1100/: led.c evk1100.h led.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/services/usb/_asf_v1
    ../../../../../../../services/usb/_asf_v1/: usb_ids.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: tasks.c queue.c timers.c list.c croutine.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: read.c port.c write.c exception.s82 portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: semphr.h StackMacros.h FreeRTOS.h mpu_wrappers.h croutine.h queue.h projdefs.h timers.h task.h portable.h list.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
