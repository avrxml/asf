# IAR project cc_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../gpio; ../../../../../../utils/debug; ../../../../../../../common/boards; ../../../../../usart; ../../../../../flashc; ../../../../../../boards; ../../../../../../utils; ../../..; ../../../../../../utils/preprocessor; ../../../../../../../common/utils; ../../../../../pm; ../../../../../intc; ../../../../../../boards/uc3_a3_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../pm/: pm_conf_clocks.c power_clocks_lib.c pm.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/gpio
    ../../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../intc/: intc.c exception.s82 intc.h
  group avr32/drivers/flashc
    ../../../../../flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../usart/: usart.c usart.h
  group avr32/drivers/cpu/cycle_counter
    ../../../: cycle_counter.h
  group avr32/drivers/cpu/cycle_counter/example
    ../../: cycle_counter_example.c
  group avr32/drivers/cpu/cycle_counter/example/at32uc3a3256_uc3_a3_xplained/iar
    ./: asf.h
  group avr32/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/uc3_a3_xplained
    ../../../../../../boards/uc3_a3_xplained/: led.c led.h uc3_a3_xplained.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
