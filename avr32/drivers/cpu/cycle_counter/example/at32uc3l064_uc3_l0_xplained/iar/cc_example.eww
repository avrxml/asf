<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cc_example.ewp</path>
	</project>
</workspace>
