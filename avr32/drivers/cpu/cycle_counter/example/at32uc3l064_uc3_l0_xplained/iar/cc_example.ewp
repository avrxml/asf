# IAR project cc_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../utils/debug; ../../../../../../boards/uc3_l0_xplained; ../../../../../../../common/boards; ../../../../../usart; ../../../../../../boards; ../../../../../../utils; ../../..; ../../../../../gpio; ../../../../../flashcdw; ../../../../../../../common/utils; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/cpu/cycle_counter
    ../../../: cycle_counter.h
  group avr32/drivers/cpu/cycle_counter/example
    ../../: cycle_counter_example.c
  group avr32/drivers/cpu/cycle_counter/example/at32uc3l064_uc3_l0_xplained
    ../: conf_clock.h conf_board.h
  group avr32/drivers/cpu/cycle_counter/example/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group avr32/drivers/flashcdw
    ../../../../../flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/usart
    ../../../../../usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../gpio/: gpio.c gpio.h
  group avr32/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../../boards/uc3_l0_xplained/: led.c uc3_l0_xplained.h led.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h genclk.h osc.h dfll.h
  group common/services/clock/uc3l
    ../../../../../../../common/services/clock/uc3l/: dfll.c sysclk.c osc.c dfll.h genclk.h osc.h sysclk.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
