<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sau_example.ewp</path>
	</project>
</workspace>
