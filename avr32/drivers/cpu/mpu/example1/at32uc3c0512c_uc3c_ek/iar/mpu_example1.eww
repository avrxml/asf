<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mpu_example1.ewp</path>
	</project>
</workspace>
