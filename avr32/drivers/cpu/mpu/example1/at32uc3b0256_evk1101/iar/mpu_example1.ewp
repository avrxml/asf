# IAR project mpu_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ..; ../../../../../../../common/services/clock; ../../../../../../utils/debug; ../../../../../../boards/evk1101; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../usart; ../../../../../flashc; ../../../../../../boards; ../../../../../../utils; ../../../../cycle_counter; ../../../../../gpio; ../../../../../../../common/utils; ../../../../../pm; ../../../../../intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../pm/: pm_conf_clocks.c power_clocks_lib.c pm.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/gpio
    ../../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/mpu
    ../../../: mpu.c mpu.h
  group avr32/drivers/cpu/mpu/example1
    ../../: mpu_example1.c mpu_exception.s82
  group avr32/drivers/cpu/mpu/example1/at32uc3b0256_evk1101
    ../: conf_board.h conf_clock.h
  group avr32/drivers/cpu/mpu/example1/at32uc3b0256_evk1101/iar
    ./: asf.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../cycle_counter/: cycle_counter.h
  group avr32/drivers/intc
    ../../../../../intc/: intc.c intc.h
  group avr32/drivers/flashc
    ../../../../../flashc/: flashc.c flashc.h
  group avr32/drivers/usart
    ../../../../../usart/: usart.c usart.h
  group avr32/boards/evk1101
    ../../../../../../boards/evk1101/: led.c led.h evk1101.h
  group avr32/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/uc3b0_b1
    ../../../../../../../common/services/clock/uc3b0_b1/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
