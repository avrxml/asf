<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\qdec_example.ewp</path>
	</project>
</workspace>
