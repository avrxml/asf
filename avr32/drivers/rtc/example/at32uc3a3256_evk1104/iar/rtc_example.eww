<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_example.ewp</path>
	</project>
</workspace>
