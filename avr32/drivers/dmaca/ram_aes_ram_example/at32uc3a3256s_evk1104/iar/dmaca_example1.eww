<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dmaca_example1.ewp</path>
	</project>
</workspace>
