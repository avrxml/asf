<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mdma_example.ewp</path>
	</project>
</workspace>
