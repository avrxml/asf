<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freqm_example.ewp</path>
	</project>
</workspace>
