<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twi_slave_example.ewp</path>
	</project>
</workspace>
