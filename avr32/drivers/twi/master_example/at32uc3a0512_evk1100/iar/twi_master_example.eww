<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twi_master_example.ewp</path>
	</project>
</workspace>
