# IAR project adcifa_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../common/services/delay; ../../../../../utils/preprocessor; ../../../../../boards/uc3c_ek; ../../../../scif; ../../../../../utils/debug; ../../../../../../common/boards; ../..; ../../../../usart; ../../../../flashc; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../utils; ../../../../cpu/cycle_counter; ../../../../gpio; ../../../../pm; ../../../../../../common/utils; ../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c flashc.h
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3c.c power_clocks_lib.h sleep.h pm_uc3c.h
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c gpio.h
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/usart
    ../../../../usart/: usart.c usart.h
  group avr32/drivers/adcifa
    ../../../: adcifa.c adcifa.h
  group avr32/drivers/adcifa/example1
    ../../: adcifa_example.c conf_clock.h
  group avr32/drivers/adcifa/example1/at32uc3c0512c_uc3c_ek
    ../: conf_example.h
  group avr32/drivers/adcifa/example1/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/boards/uc3c_ek
    ../../../../../boards/uc3c_ek/: led.c led.h uc3c_ek.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/uc3c
    ../../../../../../common/services/clock/uc3c/: osc.c sysclk.c pll.c osc.h genclk.h sysclk.h pll.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../common/boards/: board.h
