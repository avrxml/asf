<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\smc_example.ewp</path>
	</project>
</workspace>
