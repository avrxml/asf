<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dip204_example.ewp</path>
	</project>
</workspace>
