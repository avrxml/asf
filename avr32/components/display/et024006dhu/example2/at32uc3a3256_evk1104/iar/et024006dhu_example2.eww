<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\et024006dhu_example2.ewp</path>
	</project>
</workspace>
