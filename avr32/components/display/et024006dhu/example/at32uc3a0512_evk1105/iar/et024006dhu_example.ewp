# IAR project et024006dhu_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../boards/evk1105; ../../..; ../../../../../../utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../../common/boards; ../../../../../../drivers/ebi/smc; ../../../../../../drivers/cpu/cycle_counter; ../../../../../../drivers/flashc; ../../../../../../boards; ../../../../../../utils; ../../conf; ../../../../../../drivers/gpio; ../../../../../../drivers/intc; ../../../../../../drivers/pm; ../../../../../../../common/utils; ../../../../../../drivers/pwm; ../../../../../../../common/services/delay; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/display/et024006dhu
    ../../../: et024006dhu.c et024006dhu.h smc_et024006dhu.h
  group avr32/components/display/et024006dhu/example
    ../../: avr32_logo.c et024006dhu_example.c avr32_logo.h
  group avr32/components/display/et024006dhu/example/conf
    ../../conf/: conf_ebi.h conf_et024006dhu.h conf_clock.h
  group avr32/components/display/et024006dhu/example/at32uc3a0512_evk1105/iar
    ./: asf.h
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/pwm
    ../../../../../../drivers/pwm/: pwm.c pwm.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1105
    ../../../../../../boards/evk1105/: led.c evk1105.h led.h
  group avr32/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/uc3a0_a1
    ../../../../../../../common/services/clock/uc3a0_a1/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
