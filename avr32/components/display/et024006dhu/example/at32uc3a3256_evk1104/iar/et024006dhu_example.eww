<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\et024006dhu_example.ewp</path>
	</project>
</workspace>
