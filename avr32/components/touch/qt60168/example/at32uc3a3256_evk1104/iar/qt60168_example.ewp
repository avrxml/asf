# IAR project qt60168_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../display/et024006dhu; ../../../../../../utils/preprocessor; ../../../../../../utils/debug; ../../../../../../drivers/ebi/smc; ../../../../../../../common/boards; ../../../../../../drivers/usart; ../../../../../../drivers/flashc; ../../../../../../boards/evk1104; ../../../../../../boards; ../../../../../../utils; ../../../../../../drivers/cpu/cycle_counter; ../../../../../../drivers/gpio; ../../../../../../drivers/pm; ../../../../../../../common/utils; ../../conf; ../../../../../../drivers/spi; ../../../../../../drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/touch/qt60168
    ../../../: qt60168.c qt60168.h
  group avr32/components/touch/qt60168/example
    ../../: qt60168_example.c
  group avr32/components/touch/qt60168/example/conf
    ../../conf/: conf_qt60168.h conf_ebi.h conf_et024006dhu.h
  group avr32/components/touch/qt60168/example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group avr32/components/display/et024006dhu
    ../../../../../display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/eic
    ../../../../../../drivers/eic/: eic.c eic.h
  group avr32/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/boards/evk1104
    ../../../../../../boards/evk1104/: led.c led.h evk1104.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
