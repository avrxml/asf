<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\qt60168_example.ewp</path>
	</project>
</workspace>
