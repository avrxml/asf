<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\qt1081_example.ewp</path>
	</project>
</workspace>
