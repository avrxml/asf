<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\resitive_example.ewp</path>
	</project>
</workspace>
