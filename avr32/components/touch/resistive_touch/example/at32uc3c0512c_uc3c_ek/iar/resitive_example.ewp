# IAR project resitive_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../display/et024006dhu; ../../../../../../utils/preprocessor; ../../../../../../boards/uc3c_ek; ../../../../../../drivers/scif; ../../../../../../utils/debug; ../../../../../../drivers/ebi/smc; ../../../../../../../common/boards; ../../../../../../boards; ../../../../../../drivers/usart; ../../../../../../drivers/flashc; ../../..; ../../../../../../utils; ../../../../../../drivers/cpu/cycle_counter; ../../../../../../drivers/gpio; ../../../../../../../common/utils; ../../../../../../drivers/pm; ../../../../../../drivers/intc; ../../../../../../drivers/adcifa; ../../conf; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/adcifa
    ../../../../../../drivers/adcifa/: adcifa.c adcifa.h
  group avr32/drivers/scif
    ../../../../../../drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: power_clocks_lib.c pm_uc3c.c sleep.h pm_uc3c.h power_clocks_lib.h
  group avr32/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3c_ek
    ../../../../../../boards/uc3c_ek/: led.c uc3c_ek.h led.h
  group avr32/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group avr32/components/touch/resistive_touch
    ../../../: rtouch.c rtouch.h
  group avr32/components/touch/resistive_touch/example
    ../../: rtouch_calibrate.c rtouch_example.c rtouch_calibrate.h
  group avr32/components/touch/resistive_touch/example/conf
    ../../conf/: conf_rtouch.h conf_ebi.h conf_et024006dhu.h
  group avr32/components/touch/resistive_touch/example/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group avr32/components/display/et024006dhu
    ../../../../../display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../common/boards/: board.h
