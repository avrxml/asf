<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at42qt1060_example.ewp</path>
	</project>
</workspace>
