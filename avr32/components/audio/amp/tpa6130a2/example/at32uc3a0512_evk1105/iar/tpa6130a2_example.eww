<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tpa6130a2_example.ewp</path>
	</project>
</workspace>
