# IAR project tpa6130a2_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../utils/preprocessor; ../../../../../../../drivers/ssc/i2s; ../../../../../../../drivers/abdac; ../../../../../../../utils/debug; ../../../../../../../drivers/twim; ../../../../../../../drivers/pdca; ../../..; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../../common/boards; ../../../../../../../boards; ../../../../../../../utils; ../../../../..; ../../../../../../../boards/evk1104; ../../../../../../../drivers/gpio; ../../../../../../../drivers/intc; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/audio
    ../../../../../: audio.h
  group avr32/components/audio/amp/tpa6130a2
    ../../../: tpa6130.c tpa6130.h
  group avr32/components/audio/amp/tpa6130a2/example
    ../../: tpa6130_example.c conf_twi.h sound.h conf_twim.h conf_tpa6130.h
  group avr32/components/audio/amp/tpa6130a2/example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group avr32/drivers/abdac
    ../../../../../../../drivers/abdac/: abdac.c abdac.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/twim
    ../../../../../../../drivers/twim/: twim.c twim.h
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/ssc/i2s
    ../../../../../../../drivers/ssc/i2s/: ssc_i2s.c ssc_i2s.h
  group avr32/drivers/pdca
    ../../../../../../../drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c power_clocks_lib.h pm.h sleep.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/boards/evk1104
    ../../../../../../../boards/evk1104/: led.c evk1104.h led.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
