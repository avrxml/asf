<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mci_example.ewp</path>
	</project>
</workspace>
