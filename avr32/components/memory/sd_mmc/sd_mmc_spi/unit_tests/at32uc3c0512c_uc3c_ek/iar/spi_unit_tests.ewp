# IAR project spi_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3C_EK; SD_MMC_SPI_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../conf; ../../../../../../../utils/preprocessor; ../../../../../../../boards/uc3c_ek; ../../../../../../../../common/services/clock; ..; ../../../../../../../../common/services/serial; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/gpio; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../../common/utils; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/spi; ../../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/uc3c
    ../../../../../../../../common/services/clock/uc3c/: pll.c sysclk.c osc.c sysclk.h pll.h genclk.h osc.h
  group common/services/storage/ctrl_access
    ../../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../: sd_mmc_spi.c sd_mmc_spi_mem.c sd_mmc_spi.h sd_mmc_spi_mem.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests
    ../../: unit_tests.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests/at32uc3c0512c_uc3c_ek
    ../: conf_usart_serial.h conf_test.h conf_sd_mmc_spi.h conf_board.h conf_clock.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests/conf
    ../../conf/: conf_access.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/boards/uc3c_ek
    ../../../../../../../boards/uc3c_ek/: led.c init.c uc3c_ek.h led.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
