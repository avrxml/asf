# IAR project spi_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; SD_MMC_SPI_ENABLE; BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../../drivers/flashc; ..; ../../../../../../../utils/preprocessor; ../../../../../../../../common/services/clock; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../../common/services/serial; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../boards/evk1105; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/gpio; ../../conf; ../../../../../../../../common/utils; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/spi; ../../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/storage/ctrl_access
    ../../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/uc3a0_a1
    ../../../../../../../../common/services/clock/uc3a0_a1/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../: sd_mmc_spi.c sd_mmc_spi_mem.c sd_mmc_spi.h sd_mmc_spi_mem.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests
    ../../: unit_tests.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests/at32uc3a0512_evk1105
    ../: conf_usart_serial.h conf_test.h conf_clock.h conf_sd_mmc_spi.h conf_board.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests/at32uc3a0512_evk1105/iar
    ./: asf.h
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests/conf
    ../../conf/: conf_access.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../../drivers/spi/: spi.c spi.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/boards/evk1105
    ../../../../../../../boards/evk1105/: init.c led.c led.h evk1105.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
