<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_example.ewp</path>
	</project>
</workspace>
