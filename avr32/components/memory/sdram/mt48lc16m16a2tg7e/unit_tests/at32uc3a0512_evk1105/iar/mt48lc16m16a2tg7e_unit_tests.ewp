# IAR project mt48lc16m16a2tg7e_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../drivers/flashc; ../../../../../../../../common/services/serial; ../../../../../../../utils/preprocessor; ../../../../../../../../common/services/clock; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../common/boards; ../../../../../../../drivers/ebi/sdramc; ../../../../../../../drivers/usart; ..; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../drivers/gpio; ../../../../../../../utils/debug; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../../../..; ../..; ../../../../../../../boards/evk1105; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3a0_a1
    ../../../../../../../../common/services/clock/uc3a0_a1/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c power_clocks_lib.h pm.h sleep.h
  group avr32/drivers/ebi/sdramc
    ../../../../../../../drivers/ebi/sdramc/: sdramc.c sdramc.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1105
    ../../../../../../../boards/evk1105/: init.c led.c led.h evk1105.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e
    ../../../: mt48lc16m16a2tg7e.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e/unit_tests
    ../../: unit_tests.c main.c unit_tests.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e/unit_tests/at32uc3a0512_evk1105
    ../: conf_usart_serial.h conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e/unit_tests/at32uc3a0512_evk1105/iar
    ./: asf.h
