<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mt48lc16m16a2tg7e_unit_tests.ewp</path>
	</project>
</workspace>
