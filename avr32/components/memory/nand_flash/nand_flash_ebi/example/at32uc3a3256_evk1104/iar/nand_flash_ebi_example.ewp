# IAR project nand_flash_ebi_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../../boards; ../../../../../../../drivers/pm; ../../../../../../../utils/debug; ../../../../../../../../common/services/serial; ../../../../../../../boards/evk1104; ../../../../../../../utils; ../../../../../../../drivers/gpio; ../../../../../../../../common/utils; ../../conf; ../../../../../../../drivers/ecchrs; ../../../../../../../../common/services/clock; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../drivers/ebi/smc; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../..; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/memory/nand_flash/nand_flash_ebi
    ../../../: nf.c nf_2KB.h nf.h nf_512B.h
  group avr32/components/memory/nand_flash/nand_flash_ebi/example
    ../../: nf_example.c
  group avr32/components/memory/nand_flash/nand_flash_ebi/example/conf
    ../../conf/: conf_usart_serial.h conf_clock.h conf_stdio_serial.h conf_ebi.h smc_nf.h conf_nf.h conf_board.h
  group avr32/components/memory/nand_flash/nand_flash_ebi/example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/ebi/smc
    ../../../../../../../drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c power_clocks_lib.h pm.h sleep.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/drivers/ecchrs
    ../../../../../../../drivers/ecchrs/: ecchrs.h
  group avr32/boards/evk1104
    ../../../../../../../boards/evk1104/: init.c led.c evk1104.h led.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../../../../../common/services/serial/uc3_usart/: usart_serial.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
