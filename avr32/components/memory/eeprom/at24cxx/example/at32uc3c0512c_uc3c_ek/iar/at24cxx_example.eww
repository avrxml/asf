<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at24cxx_example.ewp</path>
	</project>
</workspace>
