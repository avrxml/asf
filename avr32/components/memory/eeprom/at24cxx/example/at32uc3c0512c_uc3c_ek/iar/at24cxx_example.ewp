# IAR project at24cxx_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../utils; ../..; ../../../../../../../drivers/twim; ../../../../../../../boards/uc3c_ek; ../../../../../../../drivers/scif; ../../../../../../../utils/debug; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../boards; ../../..; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../../../../../../../drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/memory/eeprom/at24cxx
    ../../../: at24cxx.c at24cxx.h
  group avr32/components/memory/eeprom/at24cxx/example
    ../../: at24cxx_example.c conf_at24cxx.h conf_twim.h
  group avr32/components/memory/eeprom/at24cxx/example/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/twim
    ../../../../../../../drivers/twim/: twim.c twim.h
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c power_clocks_lib.h pm_uc3c.h sleep.h
  group avr32/drivers/scif
    ../../../../../../../drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c usart.h
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3c_ek
    ../../../../../../../boards/uc3c_ek/: led.c uc3c_ek.h led.h
  group avr32/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c print_funcs.h
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group avr32/utils/header_files
    ../../../../../../../utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
