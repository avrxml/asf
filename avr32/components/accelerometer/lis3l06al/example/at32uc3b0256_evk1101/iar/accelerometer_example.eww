<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\accelerometer_example.ewp</path>
	</project>
</workspace>
