<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc32_example.ewp</path>
	</project>
</workspace>
