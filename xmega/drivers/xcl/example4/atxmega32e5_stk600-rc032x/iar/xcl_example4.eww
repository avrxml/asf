<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xcl_example4.ewp</path>
	</project>
</workspace>
