<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xcl_example3.ewp</path>
	</project>
</workspace>
