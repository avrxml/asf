<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xcl_example2.ewp</path>
	</project>
</workspace>
