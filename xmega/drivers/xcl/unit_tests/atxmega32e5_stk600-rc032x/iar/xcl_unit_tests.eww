<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xcl_unit_tests.ewp</path>
	</project>
</workspace>
