<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xcl_example1.ewp</path>
	</project>
</workspace>
