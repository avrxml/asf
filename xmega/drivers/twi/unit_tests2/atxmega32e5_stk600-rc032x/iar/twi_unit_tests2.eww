<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twi_unit_tests2.ewp</path>
	</project>
</workspace>
