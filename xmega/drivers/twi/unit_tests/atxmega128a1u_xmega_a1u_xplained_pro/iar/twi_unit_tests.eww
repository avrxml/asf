<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\twi_unit_tests.ewp</path>
	</project>
</workspace>
