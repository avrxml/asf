<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pmic_example_xmegae.ewp</path>
	</project>
</workspace>
