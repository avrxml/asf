<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pmic_example.ewp</path>
	</project>
</workspace>
