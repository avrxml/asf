<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_simulator_example1.ewp</path>
	</project>
</workspace>
