<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\unit_tests_sram.ewp</path>
	</project>
</workspace>
