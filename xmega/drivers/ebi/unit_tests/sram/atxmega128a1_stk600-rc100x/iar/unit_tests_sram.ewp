# IAR project unit_tests_sram.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; BOARD=STK600_RC100X; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../boards/stk600/rc100x; ../../../../../pmic; ../../../../../../utils; ..; ../../..; ../../../../../../../common/services/serial; ../../../../../../../common/services/ioport; ../..; ../../../../../../../common/services/serial/xmega_usart; ../../../../../usart; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../..; ../../../../../../../common/services/clock; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../boards; ../../../../../../../common/services/gpio; ../../../../../../../common/services/hugemem; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../sleep; ../../../../../cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; BOARD=STK600_RC100X; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../../common/services/serial/xmega_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/xmega
    ../../../../../../../common/services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/hugemem
    ../../../../../../../common/services/hugemem/: hugemem.h
  group common/services/hugemem/avr8
    ../../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c hugemem.h
  group common/services/hugemem/generic
    ../../../../../../../common/services/hugemem/generic/: hugemem.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group xmega/drivers/ebi
    ../../../../: ebi.c ebi_port.h ebi.h
  group xmega/drivers/ebi/unit_tests
    ../../../: common_tests.c common_tests.h
  group xmega/drivers/ebi/unit_tests/sram
    ../../: unit_tests.c
  group xmega/drivers/ebi/unit_tests/sram/atxmega128a1_stk600-rc100x
    ../: conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group xmega/drivers/ebi/unit_tests/sram/atxmega128a1_stk600-rc100x/iar
    ./: asf.h
  group xmega/drivers/usart
    ../../../../../usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../../sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../pmic/: pmic.h
  group xmega/boards/stk600/rc100x
    ../../../../../../boards/stk600/rc100x/: init.c stk600_rc100x.h led.h
  group xmega/utils
    ../../../../../../utils/: progmem.h status_codes.h compiler.h assembler.h
  group xmega/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../../utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../utils/bit_handling/: clz_ctz.h
