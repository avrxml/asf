<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\unit_tests_sdram.ewp</path>
	</project>
</workspace>
