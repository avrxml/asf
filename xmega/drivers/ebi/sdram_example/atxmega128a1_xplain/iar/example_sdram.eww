<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_sdram.ewp</path>
	</project>
</workspace>
