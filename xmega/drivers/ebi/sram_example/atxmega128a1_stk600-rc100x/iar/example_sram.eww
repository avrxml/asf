<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_sram.ewp</path>
	</project>
</workspace>
