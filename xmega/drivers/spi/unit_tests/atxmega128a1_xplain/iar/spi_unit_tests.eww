<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_unit_tests.ewp</path>
	</project>
</workspace>
