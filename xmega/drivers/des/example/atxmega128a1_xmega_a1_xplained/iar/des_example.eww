<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\des_example.ewp</path>
	</project>
</workspace>
