<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\des_unit_tests.ewp</path>
	</project>
</workspace>
