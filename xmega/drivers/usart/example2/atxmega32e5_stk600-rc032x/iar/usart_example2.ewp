# IAR project usart_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../boards/stk600/rc032x; ../../../../pmic; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ..; ../../../../../utils/preprocessor; ../../..; ../../../../../boards; ../../../../../../common/utils; ../../../../../../common/services/sleepmgr; ../../../../sleep; ../../../../xcl; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  group xmega/drivers/usart
    ../../../: usart_xmegae.c usart.c usart_xmegae.h usart.h
  group xmega/drivers/usart/example2
    ../../: usart_example2.c
  group xmega/drivers/usart/example2/atxmega32e5_stk600-rc032x
    ../: conf_clock.h conf_usart_example.h conf_board.h conf_sleepmgr.h conf_xcl.h
  group xmega/drivers/usart/example2/atxmega32e5_stk600-rc032x/iar
    ./: asf.h
  group xmega/drivers/xcl
    ../../../../xcl/: xcl.c xcl_glue_logic.h xcl.h xcl_timer.h
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../pmic/: pmic.h
  group xmega/boards/stk600/rc032x
    ../../../../../boards/stk600/rc032x/: init.c stk600_rc032x.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
