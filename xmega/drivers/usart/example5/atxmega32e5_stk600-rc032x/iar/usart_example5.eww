<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_example5.ewp</path>
	</project>
</workspace>
