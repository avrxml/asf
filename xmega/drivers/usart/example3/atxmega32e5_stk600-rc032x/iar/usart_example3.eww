<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_example3.ewp</path>
	</project>
</workspace>
