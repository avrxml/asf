<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_example.ewp</path>
	</project>
</workspace>
