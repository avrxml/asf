<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_example4.ewp</path>
	</project>
</workspace>
