# IAR project nvm_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32d4 ATxmega32D4
  ICCAVR.CCDefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../boards/stk600/rc044x; ../../../../../../common/services/ioport; ../../../../../boards; ../../..; ../../../../../../common/utils; ../../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  group xmega/boards/stk600/rc044x
    ../../../../../boards/stk600/rc044x/: init.c stk600_rc044x.h led.h
  group xmega/drivers/nvm
    ../../../: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/nvm/example1
    ../../: example1_xmega.c
  group xmega/drivers/nvm/example1/atxmega32d4_stk600-rc044x
    ../: conf_clock.h conf_board.h conf_example.h
  group xmega/drivers/nvm/example1/atxmega32d4_stk600-rc044x/iar
    ./: asf.h
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h osc.h sysclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
