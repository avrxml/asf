<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example1.ewp</path>
	</project>
</workspace>
