<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example3.ewp</path>
	</project>
</workspace>
