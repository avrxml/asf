<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example2_gfx.ewp</path>
	</project>
</workspace>
