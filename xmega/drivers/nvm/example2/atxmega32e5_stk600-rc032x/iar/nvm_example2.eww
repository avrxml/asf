<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example2.ewp</path>
	</project>
</workspace>
