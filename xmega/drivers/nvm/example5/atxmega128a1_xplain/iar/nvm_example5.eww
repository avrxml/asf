<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example5.ewp</path>
	</project>
</workspace>
