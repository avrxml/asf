<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example4.ewp</path>
	</project>
</workspace>
