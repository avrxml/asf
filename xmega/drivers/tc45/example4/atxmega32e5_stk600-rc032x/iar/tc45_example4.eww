<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc45_example4.ewp</path>
	</project>
</workspace>
