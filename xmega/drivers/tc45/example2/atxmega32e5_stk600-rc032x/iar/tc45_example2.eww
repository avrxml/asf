<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc45_example2.ewp</path>
	</project>
</workspace>
