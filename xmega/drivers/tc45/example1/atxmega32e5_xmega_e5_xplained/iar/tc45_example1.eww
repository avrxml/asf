<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc45_example1.ewp</path>
	</project>
</workspace>
