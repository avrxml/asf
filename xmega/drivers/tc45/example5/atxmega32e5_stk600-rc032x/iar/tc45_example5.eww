<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc45_example5.ewp</path>
	</project>
</workspace>
