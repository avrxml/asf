<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc45_example3.ewp</path>
	</project>
</workspace>
