<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dac_example1.ewp</path>
	</project>
</workspace>
