<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dac_example2.ewp</path>
	</project>
</workspace>
