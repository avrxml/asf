<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dac_unit_tests.ewp</path>
	</project>
</workspace>
