<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ac_example2.ewp</path>
	</project>
</workspace>
