<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ac_example.ewp</path>
	</project>
</workspace>
