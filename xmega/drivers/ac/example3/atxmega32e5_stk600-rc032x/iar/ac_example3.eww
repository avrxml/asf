<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ac_example3.ewp</path>
	</project>
</workspace>
