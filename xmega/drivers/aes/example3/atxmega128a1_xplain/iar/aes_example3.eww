<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_example3.ewp</path>
	</project>
</workspace>
