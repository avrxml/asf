<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_unit_tests.ewp</path>
	</project>
</workspace>
