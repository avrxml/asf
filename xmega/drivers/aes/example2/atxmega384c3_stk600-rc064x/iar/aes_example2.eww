<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_example2.ewp</path>
	</project>
</workspace>
