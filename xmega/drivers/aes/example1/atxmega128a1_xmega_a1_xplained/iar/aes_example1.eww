<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_example1.ewp</path>
	</project>
</workspace>
