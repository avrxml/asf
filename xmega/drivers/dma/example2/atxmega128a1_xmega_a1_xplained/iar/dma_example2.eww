<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dma_example2.ewp</path>
	</project>
</workspace>
