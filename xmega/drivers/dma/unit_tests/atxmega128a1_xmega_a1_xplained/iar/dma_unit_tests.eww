<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dma_unit_tests.ewp</path>
	</project>
</workspace>
