<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dma_example.ewp</path>
	</project>
</workspace>
