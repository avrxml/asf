<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example8.ewp</path>
	</project>
</workspace>
