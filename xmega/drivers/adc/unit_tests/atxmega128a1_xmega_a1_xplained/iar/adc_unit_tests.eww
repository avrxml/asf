<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_unit_tests.ewp</path>
	</project>
</workspace>
