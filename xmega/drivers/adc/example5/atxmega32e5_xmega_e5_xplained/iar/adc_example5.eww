<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example5.ewp</path>
	</project>
</workspace>
