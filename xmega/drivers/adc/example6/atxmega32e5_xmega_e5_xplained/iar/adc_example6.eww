<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example6.ewp</path>
	</project>
</workspace>
