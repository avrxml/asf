<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example7.ewp</path>
	</project>
</workspace>
