<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example1_gfx.ewp</path>
	</project>
</workspace>
