# IAR project adc_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm192d3 ATxmega192D3
  ICCAVR.CCDefines: BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../boards/stk600/rc064x; ..; ../../../../pmic; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../../utils/preprocessor; ../../../../sleep; ../../../../../boards; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group xmega/boards/stk600/rc064x
    ../../../../../boards/stk600/rc064x/: init.c led.h stk600_rc064x.h
  group xmega/drivers/adc
    ../../../: adc.c adc.h
  group xmega/drivers/adc/example1
    ../../: adc_example1.c
  group xmega/drivers/adc/example1/atxmega192d3_stk600-rc064x
    ../: conf_adc.h conf_clock.h conf_board.h conf_sleepmgr.h
  group xmega/drivers/adc/example1/atxmega192d3_stk600-rc064x/iar
    ./: asf.h
  group xmega/drivers/adc/xmega_bcd
    ../../../xmega_bcd/: adc_bcd.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../pmic/: pmic.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
