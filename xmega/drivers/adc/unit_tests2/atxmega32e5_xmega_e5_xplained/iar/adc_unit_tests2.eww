<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_unit_tests2.ewp</path>
	</project>
</workspace>
