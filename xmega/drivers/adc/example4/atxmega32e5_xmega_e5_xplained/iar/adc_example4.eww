<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example4.ewp</path>
	</project>
</workspace>
