<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example9.ewp</path>
	</project>
</workspace>
