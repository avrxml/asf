# IAR project adc_example2_gfx.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/delay; ../../../../pmic; ../../../../sleep; ../../../../../../common/services/clock; ..; ../../../../../../common/services/spi; ../../../../../../common/services/gpio; ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../../utils; ../../../../../../common/services/gfx_mono; ../../../../../boards/xmega_a3bu_xplained; ../../../../../../common/services/ioport; ../../../../usart; ../../../../cpu; ../../../../../boards; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../..; ../../../../../../common/components/display/st7565r; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/adc
    ../../../: adc.c adc.h
  group xmega/drivers/adc/example2
    ../../: adc_example2_gfx.c
  group xmega/drivers/adc/example2/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_usart_spi.h conf_adc.h conf_clock.h conf_board.h conf_sysfont.h conf_sleepmgr.h conf_example.h conf_st7565r.h
  group xmega/drivers/adc/example2/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group xmega/drivers/adc/xmega_aau
    ../../../xmega_aau/: adc_aau.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/components/display/st7565r
    ../../../../../../common/components/display/st7565r/: st7565r.c st7565r.h
  group common/services/gfx_mono
    ../../../../../../common/services/gfx_mono/: gfx_mono_framebuffer.c gfx_mono_text.c gfx_mono_generic.c gfx_mono_c12832_a1z.c sysfont.c gfx_mono_text.h gfx_mono.h sysfont.h gfx_mono_c12832_a1z.h gfx_mono_generic.h gfx_mono_framebuffer.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/spi
    ../../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
