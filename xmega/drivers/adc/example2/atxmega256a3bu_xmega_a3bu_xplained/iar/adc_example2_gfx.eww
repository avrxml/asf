<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example2_gfx.ewp</path>
	</project>
</workspace>
