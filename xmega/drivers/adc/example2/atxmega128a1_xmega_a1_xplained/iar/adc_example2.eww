<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example2.ewp</path>
	</project>
</workspace>
