<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\qdec_example1.ewp</path>
	</project>
</workspace>
