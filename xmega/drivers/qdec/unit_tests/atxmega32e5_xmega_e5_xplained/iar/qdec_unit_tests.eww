<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\qdec_unit_tests.ewp</path>
	</project>
</workspace>
