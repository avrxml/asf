<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\crc_example2.ewp</path>
	</project>
</workspace>
