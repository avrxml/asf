<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\crc_example3.ewp</path>
	</project>
</workspace>
