# IAR project crc_unit_test.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../pmic; ../../../../../../common/boards; ../../../../../utils; ../../../../dma; ../../../../../boards/stk600/rc064x; ../../../../../../common/services/serial; ../../../../../../common/services/ioport; ../..; ../../../../../../common/services/serial/xmega_usart; ../../../../usart; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../common/services/gpio; ../../../../../../common/services/hugemem; ..; ../../..; ../../../../../utils/preprocessor; ../../../../sleep; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../common/services/serial/xmega_usart/: usart_serial.h
  group common/services/hugemem
    ../../../../../../common/services/hugemem/: hugemem.h
  group common/services/hugemem/avr8
    ../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c hugemem.h
  group common/services/hugemem/generic
    ../../../../../../common/services/hugemem/generic/: hugemem.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group xmega/boards/stk600/rc064x
    ../../../../../boards/stk600/rc064x/: init.c led.h stk600_rc064x.h
  group xmega/drivers/crc
    ../../../: crc.c crc.h
  group xmega/drivers/crc/unit_tests
    ../../: unit_tests.c
  group xmega/drivers/crc/unit_tests/atxmega256a3u_stk600-rc064x
    ../: conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group xmega/drivers/crc/unit_tests/atxmega256a3u_stk600-rc064x/iar
    ./: asf.h
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../usart/: usart.c usart.h
  group xmega/drivers/dma
    ../../../../dma/: dma.c dma.h
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../pmic/: pmic.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
