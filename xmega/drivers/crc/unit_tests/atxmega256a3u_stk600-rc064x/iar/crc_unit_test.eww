<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\crc_unit_test.ewp</path>
	</project>
</workspace>
