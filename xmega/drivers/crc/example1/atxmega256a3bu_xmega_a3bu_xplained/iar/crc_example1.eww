<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\crc_example1.ewp</path>
	</project>
</workspace>
