<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\edma_unit_tests.ewp</path>
	</project>
</workspace>
