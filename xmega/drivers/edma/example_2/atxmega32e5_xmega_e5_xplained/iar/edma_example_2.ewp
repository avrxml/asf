# IAR project edma_example_2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/delay; ../../../../pmic; ../../..; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/services/spi; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../../common/services/gfx_mono; ../../../../../boards/xmega_e5_xplained; ../../../../../../common/services/ioport; ../../../../usart; ../../../../../../common/components/display/ssd1306; ../../../../../boards; ../../../../sleep; ../../../../../../common/services/sleepmgr; ..; ../../../../xcl; ../../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  group common/components/display/ssd1306
    ../../../../../../common/components/display/ssd1306/: ssd1306.c font.c ssd1306.h font.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gfx_mono
    ../../../../../../common/services/gfx_mono/: gfx_mono_framebuffer.c gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_generic.c sysfont.c gfx_mono_text.h gfx_mono.h sysfont.h gfx_mono_generic.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group xmega/drivers/edma
    ../../../: edma.c edma.h
  group xmega/drivers/edma/example_2
    ../../: edma_example_2.c
  group xmega/drivers/edma/example_2/atxmega32e5_xmega_e5_xplained
    ../: conf_usart_spi.h conf_ssd1306.h conf_clock.h conf_board.h conf_sysfont.h conf_sleepmgr.h conf_xcl.h conf_example.h
  group xmega/drivers/edma/example_2/atxmega32e5_xmega_e5_xplained/iar
    ./: asf.h
  group xmega/drivers/usart
    ../../../../usart/: usart_xmegae.c usart.c usart_xmegae.h usart.h
  group xmega/drivers/xcl
    ../../../../xcl/: xcl.c xcl_glue_logic.h xcl.h xcl_timer.h
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../pmic/: pmic.h
  group xmega/boards/xmega_e5_xplained
    ../../../../../boards/xmega_e5_xplained/: init.c led.h xmega_e5_xplained.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
