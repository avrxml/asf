<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\edma_example_2.ewp</path>
	</project>
</workspace>
