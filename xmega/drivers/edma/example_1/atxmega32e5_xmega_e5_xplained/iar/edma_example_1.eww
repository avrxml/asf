<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\edma_example_1.ewp</path>
	</project>
</workspace>
