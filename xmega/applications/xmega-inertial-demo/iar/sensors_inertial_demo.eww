<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_inertial_demo.ewp</path>
	</project>
</workspace>
