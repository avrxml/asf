<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_a1_xplained_demo.ewp</path>
	</project>
</workspace>
