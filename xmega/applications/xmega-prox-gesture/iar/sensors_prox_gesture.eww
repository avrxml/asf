<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_prox_gesture.ewp</path>
	</project>
</workspace>
