<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_lightprox_demo.ewp</path>
	</project>
</workspace>
