<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avrsbin1_display.ewp</path>
	</project>
</workspace>
