# IAR project avrsbin1_calibrate.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/pmic; ../../../../../common/services/sensors; ../../../../utils; ../../../../../common/services/gfx_mono; ../..; ../../conf; ../../../../../common/services/twi; ../../../../../common/services/ioport; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/components/display/st7565r; ../../../../../common/services/clock; ../../../../boards/xmega_a3bu_xplained; ../../../../boards; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../drivers/twi; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/sleep; ../../../../../common/services/sensors/module_config; ../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; IOPORT_XMEGA_COMPAT
  group xmega/boards/xmega_a3bu_xplained
    ../../../../boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/drivers/twi
    ../../../../drivers/twi/: twim.c twis.c twis.h twi_common.h twim.h
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/applications/xmega_a3bu_xplained_sensors
    ../../: compass_calibrate.c sensor_demo.h
  group xmega/applications/xmega_a3bu_xplained_sensors/conf
    ../../conf/: conf_twim.h conf_sleepmgr.h conf_usart_spi.h conf_board.h conf_sysfont.h conf_st7565r.h
  group xmega/applications/xmega_a3bu_xplained_sensors/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group xmega/utils
    ../../../../utils/: compiler.h status_codes.h assembler.h progmem.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: gfx_mono_generic.c sysfont.c gfx_mono_text.c gfx_mono_framebuffer.c gfx_mono_c12832_a1z.c sysfont.h gfx_mono_generic.h gfx_mono_c12832_a1z.h gfx_mono_text.h gfx_mono.h gfx_mono_framebuffer.h
  group common/services/sensors
    ../../../../../common/services/sensors/: sensor_bus.c sensor.c sensor_platform.c sensor_nvram.c sensor_bus.h sensor_dev.h sensor_nvram.h sensor.h
  group common/services/sensors/drivers/honeywell
    ../../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c hmc5883l.h
  group common/services/sensors/drivers/bosch
    ../../../../../common/services/sensors/drivers/bosch/: bmp.c bma180.c bma_axis.inc.c bma222.c bma220.c bma150.c bma020.c bma250.c bma220.h bma180.h bma222.h bmp.h bma020.h bma_axis.inc.h bma150.h bma250.h
  group common/services/sensors/drivers/kionix
    ../../../../../common/services/sensors/drivers/kionix/: kxtf9.c kxtf9.h
  group common/services/sensors/drivers/invensense
    ../../../../../common/services/sensors/drivers/invensense/: imu3000.c itg3200.c imu3000.h itg3200.h
  group common/services/sensors/drivers/osram
    ../../../../../common/services/sensors/drivers/osram/: sfh7770.c sfh5712.c sfh5712.h sfh7770.h
  group common/services/sensors/drivers/akm
    ../../../../../common/services/sensors/drivers/akm/: ak8975.c ak8975.h
  group common/services/sensors/physics
    ../../../../../common/services/sensors/physics/: physics.c constants.h physics.h
  group common/services/sensors/module_config
    ../../../../../common/services/sensors/module_config/: conf_clock.h conf_platform.h conf_sensors.h
  group common/services/sensors/math
    ../../../../../common/services/sensors/math/: fixed_t.h precision.h fixed.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/spi
    ../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/twi
    ../../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../../common/services/twi/xmega_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/boards/sensors_xplained
    ../../../../../common/boards/sensors_xplained/: sensors_xplained.c xplained_headers.h sensors_xplained.h
  group common/components/display/st7565r
    ../../../../../common/components/display/st7565r/: st7565r.c st7565r.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
