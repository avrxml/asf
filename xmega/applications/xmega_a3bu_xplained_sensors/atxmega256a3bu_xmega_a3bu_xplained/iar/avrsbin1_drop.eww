<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avrsbin1_drop.ewp</path>
	</project>
</workspace>
