<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_compass-cal_demo.ewp</path>
	</project>
</workspace>
