<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_c3_xplained_demo.ewp</path>
	</project>
</workspace>
