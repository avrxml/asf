# IAR project xmega_c3_xplained_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x800
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: _SNS1_SNSK1_SAME_PORT_; QTOUCH_STUDIO_MASKS=1; ACCESS_USB_ENABLED; SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; ISR_CUSTOM_H="app_cpu_load.h"; SNSK1=F; QT_NUM_CHANNELS=4; _QTOUCH_; GFX_MONO_UG_2832HSWEG04=1; QT_DELAY_CYCLES=1; SNS1=F; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/components/memory/sd_mmc; ../../../../../common/services/usb/class/cdc/device; ../../../../drivers/pmic; ../..; ../../../../drivers/tc; ../../../../utils; ../../../../../common/services/gfx_mono; ../../../../../common/services/usb/class/msc; ../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../common/services/calendar; ../../../../../thirdparty/qtouch/generic/include; ../../../../utils/preprocessor; ../../../../../common/utils/stdio/stdio_usb; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/usb/class/composite/device; ../../../../drivers/adc; ../../../../../common/services/usb/class/cdc; ../../../../../common/services/usb/class/msc/device; ../../../../../common/services/clock; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../../thirdparty/fatfs/fatfs-port-r0.09/xmega; ../../../../boards; ../../../../../common/services/fifo; ..; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../drivers/usb; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../drivers/rtc; ../../../../boards/xmega_c3_xplained; ../../../../../common/services/ioport; ../../../../../thirdparty/qtouch/generic/avr8/qtouch/common; ../../../../../common/components/display/ssd1306; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _SNS1_SNSK1_SAME_PORT_; QTOUCH_STUDIO_MASKS=1; ACCESS_USB_ENABLED; SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; ISR_CUSTOM_H="app_cpu_load.h"; SNSK1=F; QT_NUM_CHANNELS=4; _QTOUCH_; GFX_MONO_UG_2832HSWEG04=1; QT_DELAY_CYCLES=1; SNS1=F; IOPORT_XMEGA_COMPAT
  group thirdparty/qtouch/generic/avr8/qtouch/lib/iar
    ../../../../../thirdparty/qtouch/generic/avr8/qtouch/lib/iar/: libv5xmg1-4qt-k-0rs.r90
  group thirdparty/qtouch/generic/avr8/qtouch/common
    ../../../../../thirdparty/qtouch/generic/avr8/qtouch/common/: qt_asm_xmega.S touch_qt_config.h
  group thirdparty/qtouch/generic/include
    ../../../../../thirdparty/qtouch/generic/include/: touch_api.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/xmega/: fattime.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c diskio.h integer.h ffconf.h ff.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: gfx_mono_generic.c sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_framebuffer.c sysfont.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_generic.h gfx_mono.h gfx_mono_framebuffer.h
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/msc
    ../../../../../common/services/usb/class/msc/: sbc_protocol.h usb_protocol_msc.h spc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../common/services/usb/class/msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/class/composite/device
    ../../../../../common/services/usb/class/composite/device/: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/cdc
    ../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udi.h udc_desc.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/calendar
    ../../../../../common/services/calendar/: calendar.c calendar.h
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c fifo.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/spi
    ../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/components/display/ssd1306
    ../../../../../common/components/display/ssd1306/: font.c ssd1306.c font.h ssd1306.h
  group common/components/memory/sd_mmc
    ../../../../../common/components/memory/sd_mmc/: sd_mmc.c sd_mmc_mem.c sd_mmc_spi.c sd_mmc_protocol.h sd_mmc.h sd_mmc_mem.h sd_mmc_spi.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../common/boards/: board.h
  group xmega/applications/xmega_c3_xplained_demo
    ../../: app_usb.c app_bitmaps.c app_microsd.c app_touch.c app_sampling.c app_cpu_load.c main.c atmel_devices_cdc_inf.h app_usb.h readme_mht.h app_microsd.h app_touch.h app_sampling.h app_cpu_load.h
  group xmega/applications/xmega_c3_xplained_demo/atxmega384c3_xmega_c3_xplained
    ../: conf_rtc.h conf_usart_spi.h conf_clock.h conf_board.h conf_usb.h conf_app_display.h conf_ssd1306.h conf_sd_mmc.h conf_sleepmgr.h conf_adc.h conf_access.h conf_fatfs.h conf_sysfont.h
  group xmega/applications/xmega_c3_xplained_demo/atxmega384c3_xmega_c3_xplained/iar
    ./: asf.h
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c adc.h
  group xmega/drivers/adc/xmega_bcd
    ../../../../drivers/adc/xmega_bcd/: adc_bcd.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group xmega/drivers/rtc
    ../../../../drivers/rtc/: rtc.c rtc.h
  group xmega/drivers/usb
    ../../../../drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/boards/xmega_c3_xplained
    ../../../../boards/xmega_c3_xplained/: init.c led.h xmega_c3_xplained.h
  group xmega/utils
    ../../../../utils/: compiler.h status_codes.h assembler.h progmem.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
