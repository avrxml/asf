# IAR project xmega_dac_calibration.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32a4u ATxmega32A4U
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/services/delay; ../../../../boards; ../../../../drivers/pmic; ../..; ../../../../../common/services/clock; ../../../../drivers/cpu; ../../../../../common/boards; ../../../../utils/preprocessor; ..; ../../../../../common/services/ioport; ../../../../drivers/sleep; ../../user_board; ../../../../drivers/dac; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../utils; ../../../../drivers/adc; ../../../../boards/dummy; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD; IOPORT_XMEGA_COMPAT
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group xmega/drivers/dac
    ../../../../drivers/dac/: dac.c dac.h
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c adc.h
  group xmega/drivers/adc/xmega_aau
    ../../../../drivers/adc/xmega_aau/: adc_aau.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/applications/xmega_dac_calibration
    ../../: main.c
  group xmega/applications/xmega_dac_calibration/user_board
    ../../user_board/: init.c user_board.h
  group xmega/applications/xmega_dac_calibration/atxmega32a4u
    ../: conf_adc.h conf_clock.h conf_board.h conf_sleepmgr.h
  group xmega/applications/xmega_dac_calibration/atxmega32a4u/iar
    ./: asf.h
  group xmega/utils
    ../../../../utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
  group xmega/boards/dummy
    ../../../../boards/dummy/: dummy_board.h
