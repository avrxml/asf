<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_dac_calibration.ewp</path>
	</project>
</workspace>
