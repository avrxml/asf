# IAR project xmega_b1_xplained_voltage_meter.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../components/display/c42048a/c42048a_full_matrix0; ../../../../drivers/pmic; ../../../../../common/services/clock; ../../../../drivers/adc; ..; ../../../../boards/xmega_b1_xplained; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/tc; ../../../../utils; ../../../../../common/services/ioport; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../boards; ../../../../drivers/lcd; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../drivers/nvm; ../..; ../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c adc.h
  group xmega/drivers/adc/xmega_bcd
    ../../../../drivers/adc/xmega_bcd/: adc_bcd.c
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group xmega/drivers/lcd
    ../../../../drivers/lcd/: lcd.c lcd.h
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/applications/xmega_b1_xplained_voltage_meter
    ../../: ui.c main.c ui.h main.h
  group xmega/applications/xmega_b1_xplained_voltage_meter/atxmega128b1_xmega_b1_xplained
    ../: conf_adc.h conf_clock.h conf_board.h conf_sleepmgr.h
  group xmega/applications/xmega_b1_xplained_voltage_meter/atxmega128b1_xmega_b1_xplained/iar
    ./: asf.h
  group xmega/boards/xmega_b1_xplained
    ../../../../boards/xmega_b1_xplained/: init.c xmega_b1_xplained.h led.h
  group xmega/components/display/c42048a/c42048a_full_matrix0
    ../../../../components/display/c42048a/c42048a_full_matrix0/: c42048a.c c42048a.h
  group xmega/utils
    ../../../../utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
