# IAR project xmega_e5_xplained_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x800
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: ISR_CUSTOM_H="app_cpu_load.h"; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/qdec; ../../../../drivers/pmic; ../../../../utils; ../../../../../common/services/gfx_mono; ..; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../common/services/serial/xmega_usart; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../..; ../../../../drivers/adc; ../../../../../common/services/clock; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards; ../../../../../common/services/fifo; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../boards/xmega_e5_xplained; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../drivers/tc45; ../../../../drivers/rtc; ../../../../utils/preprocessor; ../../../../../common/components/display/ssd1306; ../../../../drivers/sleep; ../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ISR_CUSTOM_H="app_cpu_load.h"; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: gfx_mono_generic.c sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_framebuffer.c gfx_mono.h gfx_mono_generic.h sysfont.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_framebuffer.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h genclk.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/spi
    ../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c fifo.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../common/services/serial/xmega_usart/: usart_serial.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/components/display/ssd1306
    ../../../../../common/components/display/ssd1306/: font.c ssd1306.c font.h ssd1306.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../common/boards/: board.h
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c adc.h
  group xmega/drivers/adc/xmega_e
    ../../../../drivers/adc/xmega_e/: adc_e.c
  group xmega/drivers/qdec
    ../../../../drivers/qdec/: qdec.c qdec.h
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group xmega/drivers/rtc
    ../../../../drivers/rtc/: rtc.c rtc.h
  group xmega/drivers/tc45
    ../../../../drivers/tc45/: tc45.c tc45.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/applications/xmega_e5_xplained_demo
    ../../: app_bitmaps.c app_cpu_load.c main.c app_sampling.c app_sampling.h app_cpu_load.h
  group xmega/applications/xmega_e5_xplained_demo/atxmega32e5_xmega_e5_xplained
    ../: conf_usart_spi.h conf_adc.h conf_app_display.h conf_clock.h conf_board.h conf_sleepmgr.h conf_ssd1306.h conf_sysfont.h conf_rtc.h conf_usart_serial.h
  group xmega/applications/xmega_e5_xplained_demo/atxmega32e5_xmega_e5_xplained/iar
    ./: asf.h
  group xmega/boards/xmega_e5_xplained
    ../../../../boards/xmega_e5_xplained/: init.c led.h xmega_e5_xplained.h
  group xmega/utils
    ../../../../utils/: compiler.h assembler.h progmem.h status_codes.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
