<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_lightprox_visualizer.ewp</path>
	</project>
</workspace>
