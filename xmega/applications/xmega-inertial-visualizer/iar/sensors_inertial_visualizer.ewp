# IAR project sensors_inertial_visualizer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; CONF_STDIO_REDIRECT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../common/services/usb/class/cdc/device; ../../../../common/services/sensors; ../../../utils; ../../../../common/services/twi; ../../../../common/services/ioport; ../../../../common/utils/stdio/stdio_usb; ../../../drivers/nvm; ../../../../common/services/sleepmgr; ../../../../common/utils; ../../../../common/services/usb/class/cdc; ../../../../common/services/clock; ../../../../common/services/usb/udc; ../../../../common/services/usb; ../../../boards; ../conf; ../../../../common/services/gpio; ../../../../common/services/delay; ../../../drivers/twi; ../../../boards/xmega_a3bu_xplained; ../../../drivers/usb; ../../../../common/boards; ../../../utils/preprocessor; ../../../drivers/sleep; ../../../../common/services/sensors/module_config; ../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; CONF_STDIO_REDIRECT
  group xmega/drivers/nvm
    ../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/twi
    ../../../drivers/twi/: twis.c twim.c twi_common.h twim.h twis.h
  group xmega/drivers/usb
    ../../../drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/cpu
    ../../../drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../drivers/sleep/: sleep.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/applications/xmega-inertial-visualizer/conf
    ../conf/: conf_board.h conf_usb.h conf_sleepmgr.h conf_twim.h
  group xmega/applications/xmega-inertial-visualizer/iar
    ./: asf.h
  group xmega/utils
    ../../../utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/bit_handling
    ../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group common/utils
    ../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/sensors
    ../../../../common/services/sensors/: sensor.c sensor_nvram.c sensor_platform.c sensor_bus.c sensor.h sensor_bus.h sensor_nvram.h sensor_dev.h
  group common/services/sensors/drivers/invensense
    ../../../../common/services/sensors/drivers/invensense/: imu3000.c itg3200.c itg3200.h imu3000.h
  group common/services/sensors/drivers/bosch
    ../../../../common/services/sensors/drivers/bosch/: bma150.c bma020.c bma250.c bma_axis.inc.c bma220.c bma180.c bma222.c bmp.c bma020.h bma222.h bma220.h bma250.h bma_axis.inc.h bmp.h bma150.h bma180.h
  group common/services/sensors/drivers/honeywell
    ../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c hmc5883l.h
  group common/services/sensors/drivers/osram
    ../../../../common/services/sensors/drivers/osram/: sfh5712.c sfh7770.c sfh5712.h sfh7770.h
  group common/services/sensors/drivers/kionix
    ../../../../common/services/sensors/drivers/kionix/: kxtf9.c kxtf9.h
  group common/services/sensors/drivers/akm
    ../../../../common/services/sensors/drivers/akm/: ak8975.c ak8975.h
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c physics.h constants.h
  group common/services/sensors/math
    ../../../../common/services/sensors/math/: fixed_t.h precision.h fixed.h
  group common/services/sensors/module_config
    ../../../../common/services/sensors/module_config/: conf_platform.h conf_clock.h conf_sensors.h
  group common/services/sleepmgr
    ../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../common/services/usb/udc/: udc.c udd.h udc_desc.h udc.h udi.h
  group common/services/clock
    ../../../../common/services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../common/services/clock/xmega/: sysclk.c osc.h sysclk.h pll.h
  group common/services/ioport
    ../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/twi
    ../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../common/services/twi/xmega_twi/: twi_slave.h twi_master.h
  group common/services/delay
    ../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/applications/sensors/inertial_visualizer
    ../../../../common/applications/sensors/inertial_visualizer/: main.c data_visualizer.c data_visualizer.h
  group common/boards
    ../../../../common/boards/: board.h
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c xplained_headers.h sensors_xplained.h
