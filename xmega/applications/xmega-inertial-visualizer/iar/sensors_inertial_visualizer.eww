<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_inertial_visualizer.ewp</path>
	</project>
</workspace>
