# IAR project xmega_rtc_calibration_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/pmic; ../../../../../common/services/clock; ../../../../drivers/nvm; ../../../../../common/boards; ../../../../drivers/tc45; ../../../../utils; ../../../../utils/preprocessor; ../..; ../../../../boards/dummy; ../../../../boards; ../../../../../common/utils; ../../../../../common/services/sleepmgr; ../../../../drivers/sleep; ../../../../drivers/cpu; ..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group xmega/applications/xmega_rtc_calibration_demo
    ../../: rtc_calib_procedure.c rtc_calib_main.c rtc_calib_procedure.h
  group xmega/applications/xmega_rtc_calibration_demo/atxmega32e5
    ../: conf_clock.h conf_rtc_calibration.h conf_sleepmgr.h
  group xmega/applications/xmega_rtc_calibration_demo/atxmega32e5/iar
    ./: asf.h
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/tc45
    ../../../../drivers/tc45/: tc45.c tc45.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/utils
    ../../../../utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
  group xmega/boards/dummy
    ../../../../boards/dummy/: dummy_board.h
