# IAR project xmega_b1_xplained_demo_xmega_b1_xplained_app.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: AT45DBX_ENABLE; ACCESS_USB_ENABLED; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/services/usb/class/hid; ../../../../drivers/pmic; ../../../../components/display/c42048a/c42048a_full_matrix0; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../utils; ../../../../../common/services/usb/class/msc; ../../../../../common/services/usb/class/hid/device/generic; ../../../../../common/services/ioport; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/usb/class/composite/device; ../../../../drivers/adc; ../../../../../common/services/usb/class/msc/device; ../../../../../common/services/clock; ../../../../boards/xmega_b1_xplained; ..; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/tc; ../../../../boards; ../../../../../common/services/gpio; ../..; ../../../../../common/services/usb/class/hid/device; ../../../../drivers/usb; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/lcd; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; AT45DBX_ENABLE; ACCESS_USB_ENABLED; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../common/services/usb/class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../common/services/usb/class/hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../../../common/services/usb/class/hid/device/generic/: udi_hid_generic.c udi_hid_generic.h
  group common/services/usb/class/msc
    ../../../../../common/services/usb/class/msc/: sbc_protocol.h spc_protocol.h usb_protocol_msc.h
  group common/services/usb/class/msc/device
    ../../../../../common/services/usb/class/msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/class/composite/device
    ../../../../../common/services/usb/class/composite/device/: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/spi
    ../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx_hal_spi.h at45dbx_mem.h at45dbx.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../common/boards/: board.h
  group xmega/applications/xmega_b1_xplained_demo
    ../../: ui.c usb_hid_com.c adc_sensors.c main.c ui.h usb_hid_com.h adc_sensors.h main.h
  group xmega/applications/xmega_b1_xplained_demo/atxmega128b1_xmega_b1_xplained
    ../: conf_usart_spi.h conf_access.h conf_clock.h conf_board.h conf_sleepmgr.h conf_adc.h conf_usb.h conf_at45dbx.h conf_spi_master.h
  group xmega/applications/xmega_b1_xplained_demo/atxmega128b1_xmega_b1_xplained/iar
    ./: asf.h
  group xmega/drivers/lcd
    ../../../../drivers/lcd/: lcd.c lcd.h
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c adc.h
  group xmega/drivers/adc/xmega_bcd
    ../../../../drivers/adc/xmega_bcd/: adc_bcd.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group xmega/drivers/usb
    ../../../../drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/boards/xmega_b1_xplained
    ../../../../boards/xmega_b1_xplained/: init.c xmega_b1_xplained.h led.h
  group xmega/components/display/c42048a/c42048a_full_matrix0
    ../../../../components/display/c42048a/c42048a_full_matrix0/: c42048a.c c42048a.h
  group xmega/utils
    ../../../../utils/: compiler.h assembler.h progmem.h status_codes.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
