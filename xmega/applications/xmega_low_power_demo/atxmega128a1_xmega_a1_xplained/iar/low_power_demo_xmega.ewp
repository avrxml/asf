# IAR project low_power_demo_xmega.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/services/delay; ../../../../drivers/pmic; ../../../../../common/services/clock; ../../../../../common/services/gpio; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../utils; ../../../../boards/xmega_a1_xplained; ..; ../../../../../common/services/ioport; ../../../../drivers/wdt; ../../../../boards; ../../../../../common/utils; ../../../../../common/services/sleepmgr; ../../../../drivers/sleep; ../../../../drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c pll.h sysclk.h osc.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_avr8.h
  group xmega/applications/xmega_low_power_demo
    ../../: low_power_demo.c
  group xmega/applications/xmega_low_power_demo/atxmega128a1_xmega_a1_xplained
    ../: conf_clock.h conf_low_power_demo.h conf_board.h conf_sleepmgr.h
  group xmega/applications/xmega_low_power_demo/atxmega128a1_xmega_a1_xplained/iar
    ./: asf.h
  group xmega/boards/xmega_a1_xplained
    ../../../../boards/xmega_a1_xplained/: init.c xmega_a1_xplained.h led.h
  group xmega/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../drivers/sleep/: sleep.h
  group xmega/utils
    ../../../../utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/assembler
    ../../../../utils/assembler/: iar.h
  group xmega/utils/preprocessor
    ../../../../utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../utils/bit_handling/: clz_ctz.h
