<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_adc_oversampling_demo.ewp</path>
	</project>
</workspace>
