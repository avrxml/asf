<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_pressure_demo.ewp</path>
	</project>
</workspace>
