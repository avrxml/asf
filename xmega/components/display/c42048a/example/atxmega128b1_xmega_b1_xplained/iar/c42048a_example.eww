<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\c42048a_example.ewp</path>
	</project>
</workspace>
