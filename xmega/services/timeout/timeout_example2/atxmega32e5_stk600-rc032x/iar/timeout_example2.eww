<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\timeout_example2.ewp</path>
	</project>
</workspace>
