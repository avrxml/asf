# IAR project timeout_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../drivers/pmic; ../../..; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../..; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../../boards/xmega_a3bu_xplained; ../../../../../utils/preprocessor; ../../../../../../common/services/delay; ../../../../../../common/utils; ../../../../../boards; ../../../../../drivers/nvm; ../../../../../../common/services/sleepmgr; ../../../../../drivers/sleep; ../../../../../drivers/rtc32; ../../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/drivers/rtc32
    ../../../../../drivers/rtc32/: rtc32.c rtc32.h
  group xmega/drivers/nvm
    ../../../../../drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../../drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../drivers/pmic/: pmic.h
  group xmega/services/timeout
    ../../../: timeout.c timeout.h
  group xmega/services/timeout/timeout_example2
    ../../: example2.c
  group xmega/services/timeout/timeout_example2/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_timeout.h conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h conf_rtc32.h
  group xmega/services/timeout/timeout_example2/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
