# IAR project timeout_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/serial; ../../../../../drivers/pmic; ../../..; ../../../../../../common/services/clock; ../../../../../drivers/cpu; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../boards/xmega_a1_xplained; ../../../../../../common/services/ioport; ../../../../../drivers/usart; ../../../../../boards; ../../../../../drivers/sleep; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/serial/xmega_usart; ../../../../../drivers/rtc; ../../../../../../common/services/gpio; ../..; ..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../common/services/serial/xmega_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group xmega/drivers/rtc
    ../../../../../drivers/rtc/: rtc.c rtc.h
  group xmega/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../../drivers/sleep/: sleep.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../boards/xmega_a1_xplained/: init.c xmega_a1_xplained.h led.h
  group xmega/services/timeout
    ../../../: timeout.c timeout.h
  group xmega/services/timeout/unit_tests
    ../../: unit_tests.c
  group xmega/services/timeout/unit_tests/atxmega128a1_xmega_a1_xplained
    ../: conf_test.h conf_timeout.h conf_clock.h conf_board.h conf_sleepmgr.h conf_rtc.h conf_usart_serial.h
  group xmega/services/timeout/unit_tests/atxmega128a1_xmega_a1_xplained/iar
    ./: asf.h
  group xmega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../utils/assembler/: iar.h
