<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\timeout_unit_tests.ewp</path>
	</project>
</workspace>
