<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\timeout_example1.ewp</path>
	</project>
</workspace>
