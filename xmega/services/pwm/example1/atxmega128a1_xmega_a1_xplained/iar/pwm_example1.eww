<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pwm_example1.ewp</path>
	</project>
</workspace>
