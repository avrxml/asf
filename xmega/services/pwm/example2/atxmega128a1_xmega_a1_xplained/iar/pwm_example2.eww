<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pwm_example2.ewp</path>
	</project>
</workspace>
