<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example1.ewp</path>
	</project>
</workspace>
