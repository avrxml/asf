<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_example3.ewp</path>
	</project>
</workspace>
