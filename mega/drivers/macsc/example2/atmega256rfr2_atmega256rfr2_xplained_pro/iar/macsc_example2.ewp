# IAR project macsc_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../../common/services/clock; ..; ../../../../../../common/boards; ../../../../sleep; ../../../../../../common/services/ioport; ../../../../../../common/services/gpio; ../../../../../boards; ../../../../../../common/utils; ../../../../usart; ../../../../../boards/atmega256rfr2_xplained_pro; ../..; ../../..; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/drivers/usart
    ../../../../usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/macsc
    ../../../: macsc_megarf.c macsc_megarf.h
  group mega/drivers/macsc/example2
    ../../: macsc_megarf_example2.c
  group mega/drivers/macsc/example2/atmega256rfr2_atmega256rfr2_xplained_pro
    ../: conf_clock.h conf_board.h conf_example.h
  group mega/drivers/macsc/example2/atmega256rfr2_atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group mega/drivers/sleep
    ../../../../sleep/: sleep.h sleep_megarf.h
  group mega/drivers/cpu
    ../../../../cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../utils/: status_codes.h assembler.h progmem.h compiler.h
  group mega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group mega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../common/boards/: board.h
