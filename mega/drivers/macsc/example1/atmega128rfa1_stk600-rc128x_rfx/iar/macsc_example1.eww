<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\macsc_example1.ewp</path>
	</project>
</workspace>
