<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\macsc_unit_tests.ewp</path>
	</project>
</workspace>
