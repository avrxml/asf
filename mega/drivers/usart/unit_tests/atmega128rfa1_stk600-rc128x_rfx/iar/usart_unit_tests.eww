<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_unit_tests.ewp</path>
	</project>
</workspace>
