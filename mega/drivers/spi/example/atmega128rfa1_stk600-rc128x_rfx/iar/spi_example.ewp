# IAR project spi_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../boards/stk600; ..; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../../common/services/clock; ../../..; ../../../../../../common/services/spi; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../common/utils; ../../../../usart; ../../../../../../common/services/gpio; ../../../../../boards/stk600/rc128x_rfx; ../../../../cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group mega/drivers/spi
    ../../../: spi_megarf.c spi_megarf.h
  group mega/drivers/spi/example
    ../../: spi_slave_example.c
  group mega/drivers/spi/example/atmega128rfa1_stk600-rc128x_rfx
    ../: conf_usart_spi.h conf_spi_slave_example.h conf_clock.h conf_board.h
  group mega/drivers/spi/example/atmega128rfa1_stk600-rc128x_rfx/iar
    ./: asf.h
  group mega/drivers/usart
    ../../../../usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../cpu/: mega_reset_cause.h
  group mega/boards/stk600/rc128x_rfx
    ../../../../../boards/stk600/rc128x_rfx/: init.c led.h stk600.h
  group mega/utils
    ../../../../../utils/: assembler.h status_codes.h compiler.h progmem.h
  group mega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group mega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/spi
    ../../../../../../common/services/spi/: usart_spi.h
  group common/services/spi/megarf_usart_spi
    ../../../../../../common/services/spi/megarf_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
