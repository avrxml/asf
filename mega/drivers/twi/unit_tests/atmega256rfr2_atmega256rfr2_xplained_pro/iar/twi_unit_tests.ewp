# IAR project twi_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/gpio; ../../../../../../common/services/serial/megarf_usart; ../../../../cpu; ../../../../../utils; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../common/services/delay; ../..; ../../../../../../common/utils; ../../../../usart; ../../../../../boards/atmega256rfr2_xplained_pro; ../../../../../utils/preprocessor; ..; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../common/services/ioport/mega/: ioport.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group mega/drivers/usart
    ../../../../usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/twi
    ../../../: twi_megarf.c twi_megarf.h
  group mega/drivers/twi/unit_tests
    ../../: unit_tests.c
  group mega/drivers/twi/unit_tests/atmega256rfr2_atmega256rfr2_xplained_pro
    ../: conf_test.h conf_clock.h conf_board.h conf_usart_serial.h conf_twi.h
  group mega/drivers/twi/unit_tests/atmega256rfr2_atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group mega/drivers/cpu
    ../../../../cpu/: mega_reset_cause.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group mega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group mega/utils/assembler
    ../../../../../utils/assembler/: iar.h
