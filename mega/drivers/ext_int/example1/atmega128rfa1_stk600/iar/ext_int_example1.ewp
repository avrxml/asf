# IAR project ext_int_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../..; ../../../../../boards/stk600; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../../common/boards; ../../../../../../common/services/ioport; ..; ../../../../../../common/utils; ../../../../../boards/stk600/rc128x_rfx; ../../../../../../common/services/gpio; ../../../../cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group mega/boards/stk600/rc128x_rfx
    ../../../../../boards/stk600/rc128x_rfx/: init.c led.h stk600.h
  group mega/drivers/ext_int
    ../../../: ext_int_megarf.c ext_int_megarf.h
  group mega/drivers/ext_int/example1
    ../../: ext_int_example1.c
  group mega/drivers/ext_int/example1/atmega128rfa1_stk600
    ../: conf_clock.h conf_board.h conf_interrupt.h conf_example.h
  group mega/drivers/ext_int/example1/atmega128rfa1_stk600/iar
    ./: asf.h
  group mega/drivers/cpu
    ../../../../cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../utils/: status_codes.h assembler.h compiler.h progmem.h
  group mega/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group mega/utils/assembler
    ../../../../../utils/assembler/: iar.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_avr8.h
