<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ext_int_unit_tests.ewp</path>
	</project>
</workspace>
