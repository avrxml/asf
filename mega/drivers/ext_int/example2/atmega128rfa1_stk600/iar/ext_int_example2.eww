<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ext_int_example2.ewp</path>
	</project>
</workspace>
