# IAR project eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/clock/clock_samd10_d11; ../../../../../../utils; ../../../../../../utils/cmsis/samd11/include; ../../../../../../drivers/port; ../../../../../../boards; ../../../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../..; ../../../../../../../common/boards; ../../../../../../drivers/system; ../../../../../../drivers/system/pinmux; ../../../../../../utils/preprocessor; ../../../../../../drivers/nvm; ../../..; ..; ../../../../../../utils/header_files; ../../../../../../../common/utils; ../../../../../../utils/cmsis/samd11/source; ../../../../../../boards/samd11_xplained_pro; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../../../drivers/system/clock/clock_samd10_d11/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../utils/cmsis/samd11/include/: samd11d14am.h samd11d14as.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../utils/cmsis/samd11/include/component/: nvmctrl.h dac.h dmac.h mtb.h ac.h usb.h dsu.h sercom.h tc.h pm.h rtc.h sysctrl.h wdt.h pac.h adc.h evsys.h tcc.h gclk.h eic.h port.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11d14as.h samd11c14a.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../utils/cmsis/samd11/include/instance/: dmac.h nvmctrl.h gclk.h evsys.h sercom2.h sercom1.h sercom0.h ac.h tc1.h usb.h pm.h mtb.h dac.h sysctrl.h wdt.h tc2.h eic.h port.h pac2.h rtc.h pac1.h tcc0.h dsu.h adc.h pac0.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h stringz.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/services/eeprom/emulator
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/quick_start/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/services/eeprom/emulator/quick_start/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
