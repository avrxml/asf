# IAR project eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__
  ICCARM.CCIncludePath2: ../../../../../../../drivers/port; ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../drivers/system/interrupt/system_interrupt_samr21; ../../../../../../../utils/preprocessor; ../../../../../../../utils/cmsis/samr21/source; ../../../../../../../utils; ../../..; ../../../../../../../drivers/nvm; ../../../../../../../drivers/system/power; ../../../../../../../boards; ../..; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/bod; ../../../../../../../drivers/bod/bod_sam_d_r_h; ../../../../../../../boards/samr21_xplained_pro; ../../../../../../../utils/cmsis/samr21/include; ../../../../../../../drivers/system/power/power_sam_d_r_h; ..; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../../../../../drivers/bod/bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/services/eeprom/emulator/main_array
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/main_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/main_array/quick_start/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/services/eeprom/emulator/main_array/quick_start/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../utils/cmsis/samr21/include/: samr21e18a.h samr21e16a.h samr21g16a.h samr21g18a.h samr21e19a.h samr21g17a.h samr21.h samr21e17a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../utils/cmsis/samr21/include/instance/: gclk.h rfctrl.h dsu.h mtb.h pac2.h tcc1.h pac0.h tc5.h tcc2.h rtc.h sbmatrix.h tc4.h tc3.h eic.h usb.h tcc0.h dmac.h sercom2.h ac.h sercom0.h evsys.h adc.h sercom4.h pm.h sercom1.h wdt.h sysctrl.h port.h sercom5.h sercom3.h nvmctrl.h pac1.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../utils/cmsis/samr21/include/component/: sysctrl.h hmatrixb.h ac.h evsys.h dmac.h mtb.h rfctrl.h port.h sercom.h gclk.h eic.h usb.h rtc.h nvmctrl.h pac.h pm.h tcc.h wdt.h dsu.h tc.h adc.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../utils/cmsis/samr21/include/pio/: samr21g17a.h samr21g18a.h samr21g16a.h samr21e18a.h samr21e17a.h samr21e19a.h samr21e16a.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
