# IAR project eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/clock/clock_samd20; ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../utils/preprocessor; ../../../../../../../boards/samd20_xplained_pro; ../../../../../../../utils/cmsis/samd20/source; ../../../../../../../utils; ../../..; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../..; ..; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/bod; ../../../../../../../drivers/bod/bod_sam_d_r_h; ../../../../../../../drivers/system/power/power_sam_d_r_h; ../../../../../../../../common/boards; ../../../../../../../utils/cmsis/samd20/include; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../utils/cmsis/samd20/include/: samd20j15b.h samd20e15b.h samd20e18.h samd20e17.h samd20g17.h samd20g15.h samd20j18.h samd20.h samd20e15.h samd20j16.h samd20g18.h samd20g16b.h samd20g16.h samd20g14.h samd20g17u.h samd20j14b.h samd20g18u.h samd20j17.h samd20e14.h samd20e16b.h samd20e16.h samd20j14.h samd20g14b.h samd20e14b.h samd20g15b.h samd20j16b.h samd20j15.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../utils/cmsis/samd20/include/component/: pm.h adc.h wdt.h sercom.h sysctrl.h port.h tc.h evsys.h gclk.h rtc.h ac.h eic.h nvmctrl.h pac.h dac.h dsu.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../utils/cmsis/samd20/include/instance/: tc7.h ac.h dac.h pm.h wdt.h gclk.h nvmctrl.h rtc.h sercom5.h sysctrl.h tc4.h tc1.h tc3.h tc6.h eic.h sercom3.h sercom4.h tc0.h tc2.h sercom0.h pac0.h evsys.h sercom2.h dsu.h adc.h pac2.h port.h sercom1.h pac1.h tc5.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../utils/cmsis/samd20/include/pio/: samd20e17.h samd20e15b.h samd20j17.h samd20g15.h samd20g15b.h samd20j15.h samd20g17.h samd20g18u.h samd20g18.h samd20e16b.h samd20j16.h samd20g17u.h samd20j14.h samd20g14b.h samd20j18.h samd20e15.h samd20e14b.h samd20e14.h samd20j16b.h samd20j14b.h samd20e16.h samd20g14.h samd20j15b.h samd20e18.h samd20g16b.h samd20g16.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../drivers/system/clock/clock_samd20/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../../../../../drivers/bod/bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/services/eeprom/emulator/main_array
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/main_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/main_array/quick_start/samd20_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/services/eeprom/emulator/main_array/quick_start/samd20_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
