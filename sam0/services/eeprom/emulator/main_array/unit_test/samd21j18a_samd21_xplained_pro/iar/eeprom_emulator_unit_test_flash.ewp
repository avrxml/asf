# IAR project eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../utils/cmsis/samd21/source; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ..; ../../../../../../../utils/preprocessor; ../../../../../../../utils; ../../..; ../../../../../../../drivers/nvm; ../../../../../../../drivers/sercom; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../drivers/sercom/usart; ../../../../../../../../common/services/serial; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../boards/samd21_xplained_pro; ../../../../../../../utils/cmsis/samd21/include; ../..; ../../../../../../../drivers/system/power/power_sam_d_r_h; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../utils/cmsis/samd21/include/: samd21j18a.h samd21g17d.h samd21e17a.h samd21g17au.h samd21j17d.h samd21g17a.h samd21j15a.h samd21e15bu.h samd21j15b.h samd21g18au.h samd21g15b.h samd21g15a.h samd21g16a.h samd21j16b.h samd21e15b.h samd21g17l.h samd21g16b.h samd21j16a.h samd21e17d.h samd21e17l.h samd21g18a.h samd21.h samd21e15l.h samd21e16b.h samd21e15a.h samd21e16l.h samd21g16l.h samd21e18a.h samd21j17a.h samd21e16a.h samd21e17du.h samd21g15l.h samd21e16bu.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../utils/cmsis/samd21/include/pio/: samd21g15a.h samd21g15b.h samd21g17d.h samd21e17l.h samd21e16a.h samd21g15l.h samd21e16bu.h samd21j16a.h samd21e15bu.h samd21g16a.h samd21j15a.h samd21j15b.h samd21e18a.h samd21e15a.h samd21j18a.h samd21j16b.h samd21j17a.h samd21g18a.h samd21g17au.h samd21e16l.h samd21g17a.h samd21e17a.h samd21e16b.h samd21e17du.h samd21g16l.h samd21e15l.h samd21g16b.h samd21g17l.h samd21e17d.h samd21e15b.h samd21g18au.h samd21j17d.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../utils/cmsis/samd21/include/component/: tc.h pm_variant_d.h dmac.h nvmctrl.h ac.h dsu.h pm.h port.h eic.h wdt.h i2s.h rtc.h usb.h tcc_variant_d.h nvmctrl_variant_d.h dac.h adc.h evsys.h pac.h sysctrl.h evsys_variant_d.h hmatrixb.h gclk.h sercom.h tcc_lighting.h mtb.h tcc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../utils/cmsis/samd21/include/instance/: wdt.h tcc2.h ac1.h tcc0.h dmac.h gclk.h pac1.h ac.h eic.h pm.h sercom1.h sercom4.h evsys_variant_d.h usb.h i2s.h port_variant_d.h sercom2.h adc.h nvmctrl.h port.h sbmatrix.h tc6.h tc4.h pac0.h pac2.h evsys.h nvmctrl_variant_d.h sercom5.h tc7.h tcc3.h tc5.h sercom3.h dac.h dsu.h sercom0.h tcc1.h tc3.h rtc.h mtb.h sysctrl.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/services/eeprom/emulator/main_array
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/main_array/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/main_array/unit_test/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/main_array/unit_test/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/main_array/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
