# IAR project eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAMR21_XPLAINED_PRO; _ASSERT_ENABLE_; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../drivers/port; ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../drivers/system/interrupt/system_interrupt_samr21; ../../../../../../../utils/preprocessor; ../../../../../../../utils/cmsis/samr21/source; ../../../../../../../utils; ../../..; ../../../../../../../drivers/nvm; ../../../../../../../drivers/sercom; ../../../../../../../drivers/system/power; ../../../../../../../boards; ../../../../../../../drivers/sercom/usart; ../../../../../../../../common/services/serial; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../..; ../../../../../../../boards/samr21_xplained_pro; ../../../../../../../utils/cmsis/samr21/include; ../../../../../../../drivers/system/power/power_sam_d_r_h; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ..; ../../../../../../../utils/header_files; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../utils/cmsis/samr21/include/: samr21e18a.h samr21e16a.h samr21g16a.h samr21g18a.h samr21e19a.h samr21g17a.h samr21.h samr21e17a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../utils/cmsis/samr21/include/instance/: gclk.h rfctrl.h dsu.h mtb.h pac2.h tcc1.h pac0.h tc5.h rtc.h sbmatrix.h tc4.h eic.h usb.h tcc0.h dmac.h sercom2.h ac.h sercom0.h evsys.h adc.h sercom4.h pm.h tc3.h sercom1.h wdt.h sysctrl.h tcc2.h port.h sercom5.h sercom3.h nvmctrl.h pac1.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../utils/cmsis/samr21/include/component/: sysctrl.h hmatrixb.h ac.h evsys.h dmac.h mtb.h rfctrl.h port.h sercom.h gclk.h eic.h usb.h rtc.h nvmctrl.h pac.h pm.h tcc.h wdt.h dsu.h tc.h adc.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../utils/cmsis/samr21/include/pio/: samr21g17a.h samr21g18a.h samr21g16a.h samr21e18a.h samr21e17a.h samr21e19a.h samr21e16a.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/services/eeprom/emulator/main_array
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/main_array/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/main_array/unit_test/samr21j18a_samr21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/main_array/unit_test/samr21j18a_samr21_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/main_array/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
