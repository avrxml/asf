# IAR project eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD20_XPLAINED_PRO; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/clock/clock_samd20; ../../../../../../drivers/port; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../boards/samd20_xplained_pro; ../../../../../../utils/cmsis/samd20/source; ../../../../../../utils; ../..; ../../../../../../drivers/nvm; ../../../../../../drivers/sercom; ../../../../../../boards; ../../../../../../drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../../common/utils; ../../../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../../../drivers/system/interrupt; ..; ../../..; ../../../../../../utils/cmsis/samd20/include; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../utils/header_files; ../../../../../../utils/stdio/stdio_serial; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../utils/cmsis/samd20/include/: samd20g17.h samd20e16.h samd20g15.h samd20e17.h samd20e18.h samd20g18u.h samd20j15.h samd20j17.h samd20j18.h samd20g18.h samd20e15.h samd20g17u.h samd20g14.h samd20g16.h samd20j14.h samd20j16.h samd20e14.h samd20.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../utils/cmsis/samd20/include/instance/: dac.h pac2.h gclk.h sercom4.h sercom1.h adc.h tc4.h tc0.h sercom5.h dsu.h tc2.h pm.h eic.h wdt.h tc6.h nvmctrl.h tc5.h tc3.h sercom2.h port.h sysctrl.h rtc.h tc7.h tc1.h pac1.h evsys.h sercom3.h sercom0.h pac0.h ac.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../utils/cmsis/samd20/include/pio/: samd20j14.h samd20g16.h samd20j18.h samd20j17.h samd20g17.h samd20j15.h samd20g17u.h samd20g18u.h samd20e17.h samd20e18.h samd20g15.h samd20e15.h samd20e1f.h samd20g14.h samd20e14.h samd20j16.h samd20g18.h samd20e16.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../utils/cmsis/samd20/include/component/: evsys.h dac.h ac.h gclk.h sysctrl.h eic.h tc.h nvmctrl.h port.h rtc.h dsu.h pm.h wdt.h adc.h sercom.h pac.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/services/eeprom/emulator
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/unit_test/samd20j18_samd20_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/unit_test/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
