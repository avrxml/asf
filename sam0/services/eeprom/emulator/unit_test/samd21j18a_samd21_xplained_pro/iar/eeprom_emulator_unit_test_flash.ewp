# IAR project eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samd21/source; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/clock/clock_samd21_r21; ../../../../../../drivers/port; ../../..; ../../../../../../utils/preprocessor; ../../../../../../utils; ../..; ../../../../../../drivers/nvm; ../../../../../../drivers/sercom; ..; ../../../../../../boards; ../../../../../../drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../utils/cmsis/samd21/include/component; ../../../../../../../common/utils; ../../../../../../boards/samd21_xplained_pro; ../../../../../../utils/cmsis/samd21/include; ../../../../../../utils/cmsis/samd21/include/pio; ../../../../../../utils/cmsis/samd21/include/instance; ../../../../../../../common/boards; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../utils/header_files; ../../../../../../drivers/system/interrupt/system_interrupt_samd21; ../../../../../../utils/stdio/stdio_serial; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../utils/cmsis/samd21/include/: samd21e15a.h samd21j18a.h samd21.h samd21e16a.h samd21e17a.h samd21j17a.h samd21g16a.h samd21j16a.h samd21g18a.h samd21e18a.h samd21g17a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../utils/cmsis/samd21/include/pio/: pio_samd21j18a.h pio_samd21e18a.h pio_samd21e15a.h pio_samd21e16a.h pio_samd21g16a.h pio_samd21g17a.h pio_samd21j16a.h pio_samd21j17a.h pio_samd21e17a.h pio_samd21g18a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../utils/cmsis/samd21/include/component/: component_ac.h component_gclk.h component_tcc.h component_rtc.h component_adc.h component_dmac.h component_mtb.h component_tc.h component_pac.h component_eic.h component_usb.h component_port.h component_sercom.h component_sysctrl.h component_i2s.h component_wdt.h component_pm.h component_dac.h component_dsu.h component_evsys.h component_nvmctrl.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../utils/cmsis/samd21/include/instance/: instance_adc.h instance_rtc.h instance_pac1.h instance_pm.h instance_tc7.h instance_sercom5.h instance_sercom2.h instance_tc4.h instance_evsys.h instance_dac.h instance_ac.h instance_wdt.h instance_sercom1.h instance_tc6.h instance_gclk.h instance_tcc2.h instance_sercom0.h instance_tcc0.h instance_pac2.h instance_port.h instance_tc5.h instance_sercom4.h instance_dmac.h instance_sercom3.h instance_tcc1.h instance_i2s.h instance_dsu.h instance_pac0.h instance_eic.h instance_mtb.h instance_usb.h instance_sysctrl.h instance_nvmctrl.h instance_tc3.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/services/eeprom/emulator
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/unit_test/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/unit_test/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../drivers/system/clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
