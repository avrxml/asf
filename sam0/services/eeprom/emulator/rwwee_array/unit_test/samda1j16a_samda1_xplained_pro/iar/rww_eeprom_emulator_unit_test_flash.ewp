# IAR project rww_eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../utils/preprocessor; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/sercom; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../drivers/sercom/usart; ../../../../../../../utils/cmsis/samda1/include; ../../../../../../../../common/services/serial; ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ..; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../boards/samda1_xplained_pro; ../../../../../../../drivers/system/interrupt/system_interrupt_samda; ../..; ../../../../../../../drivers/system/power/power_sam_d_r_h; ../../../../../../../utils/cmsis/samda1/source; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/rwwee_array/unit_test/samda1j16a_samda1_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/unit_test/samda1j16a_samda1_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../../drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../../utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../../utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../../utils/cmsis/samda1/include/: samda1j14a.h samda1g16b.h samda1e15b.h samda1g14b.h samda1j15a.h samda1g15b.h samda1j16b.h samda1e16a.h samda1e15a.h samda1j16a.h samda1g14a.h samda1e14b.h samda1e14a.h samda1e16b.h samda1g16a.h samda1g15a.h samda1j14b.h samda1j15b.h samda1.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../../utils/cmsis/samda1/include/pio/: samda1g16a.h samda1g14a.h samda1g16b.h samda1j16a.h samda1g15a.h samda1j16b.h samda1j14b.h samda1e16b.h samda1e14a.h samda1g15b.h samda1j15b.h samda1e15b.h samda1e16a.h samda1e15a.h samda1e14b.h samda1g14b.h samda1j14a.h samda1j15a.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../../utils/cmsis/samda1/include/instance/: pac1.h tcc0.h sercom0.h rtc.h tcc2.h sercom2.h wdt.h dac.h evsys.h sercom5.h tc7.h ac.h nvmctrl.h dmac.h usb.h tc6.h eic.h tcc1.h tc4.h gclk.h sercom4.h pac0.h dsu.h pac2.h tc3.h i2s.h mtb.h sysctrl.h sercom3.h sbmatrix.h adc.h tc5.h port.h sercom1.h pm.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../../utils/cmsis/samda1/include/component/: tcc.h usb.h gclk.h hmatrixb.h port.h nvmctrl.h tc.h ac.h adc.h wdt.h pm.h mtb.h sercom.h dac.h dsu.h i2s.h eic.h dmac.h rtc.h evsys.h pac.h sysctrl.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../../../boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
