# IAR project rww_eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMHA1G16A_XPLAINED_PRO; __SAMHA1G16A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../../utils/cmsis/samha1/include; ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../utils/preprocessor; ../../..; ../../../../../../../utils; ../../../../../../../utils/cmsis/samha1/source; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ..; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/bod; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../drivers/system/interrupt/system_interrupt_samha; ../../../../../../../drivers/bod/bod_sam_d_r_h; ../../../../../../../drivers/system/power/power_sam_d_r_h; ../..; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../boards/samha1g16a_xplained_pro; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samha
    ../../../../../../../drivers/system/interrupt/system_interrupt_samha/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../../../../../drivers/bod/bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../../../utils/cmsis/samha1/include/: samha1e15ab.h samha1e15a.h samha1.h samha1g14a.h samha1e14a.h samha1g16ab.h samha1g14ab.h samha1e16ab.h samha1g16a.h samha1e16a.h samha1e14ab.h samha1g15a.h samha1g15ab.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../../../utils/cmsis/samha1/include/component/: linctrl.h adc.h hmatrixb.h dac.h eic.h dsu.h pm.h ac.h sysctrl.h wdt.h port.h dmac.h evsys.h nvmctrl.h mtb.h gclk.h rtc.h tc.h tcc.h sercom.h pac.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../../../utils/cmsis/samha1/include/pio/: samha1g16ab.h samha1e14ab.h samha1g15ab.h samha1g15a.h samha1g16a.h samha1e16ab.h samha1e15a.h samha1e16a.h samha1g14ab.h samha1g14a.h samha1e14a.h samha1e15ab.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../../../utils/cmsis/samha1/include/instance/: nvmctrl.h eic.h sercom2.h dsu.h sercom5.h tc5.h sercom1.h tc7.h port.h dac.h linctrl.h tc3.h sercom4.h gclk.h tcc2.h tc4.h tcc0.h sercom0.h tc6.h dmac.h wdt.h evsys.h pm.h ac.h tcc1.h sbmatrix.h pac2.h sercom3.h pac1.h adc.h rtc.h sysctrl.h pac0.h mtb.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/samha1g16a_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/samha1g16a_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
