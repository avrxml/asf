# IAR project rww_eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../utils/preprocessor; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../utils/cmsis/samda1/include; ..; ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/bod; ../../../../../../../boards/samda1_xplained_pro; ../../../../../../../drivers/system/interrupt/system_interrupt_samda; ../../../../../../../drivers/bod/bod_sam_d_r_h; ../../../../../../../drivers/system/power/power_sam_d_r_h; ../..; ../../../../../../../utils/cmsis/samda1/source; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../../drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../../../../../drivers/bod/bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/samda1_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/samda1_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../../utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../../utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../../utils/cmsis/samda1/include/: samda1j14a.h samda1g16b.h samda1e15b.h samda1g14b.h samda1j15a.h samda1g15b.h samda1j16b.h samda1e16a.h samda1e15a.h samda1j16a.h samda1g14a.h samda1e14b.h samda1e14a.h samda1e16b.h samda1g16a.h samda1g15a.h samda1j14b.h samda1j15b.h samda1.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../../utils/cmsis/samda1/include/pio/: samda1g16a.h samda1g14a.h samda1g16b.h samda1j16a.h samda1g15a.h samda1j16b.h samda1j14b.h samda1e16b.h samda1e14a.h samda1g15b.h samda1j15b.h samda1e15b.h samda1e16a.h samda1e15a.h samda1e14b.h samda1g14b.h samda1j14a.h samda1j15a.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../../utils/cmsis/samda1/include/instance/: tcc0.h sercom0.h pac1.h tc4.h tcc2.h sercom2.h wdt.h dac.h evsys.h sercom5.h adc.h tc7.h ac.h nvmctrl.h dmac.h sbmatrix.h usb.h tc6.h eic.h tcc1.h gclk.h pac0.h sercom4.h dsu.h pac2.h tc3.h i2s.h mtb.h sysctrl.h sercom3.h rtc.h tc5.h port.h sercom1.h pm.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../../utils/cmsis/samda1/include/component/: tcc.h usb.h gclk.h hmatrixb.h port.h nvmctrl.h tc.h ac.h adc.h wdt.h pm.h mtb.h sercom.h dac.h dsu.h i2s.h eic.h dmac.h rtc.h evsys.h pac.h sysctrl.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../../../boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
