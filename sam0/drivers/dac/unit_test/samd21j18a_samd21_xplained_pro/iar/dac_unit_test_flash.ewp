# IAR project dac_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD21_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; _ASSERT_ENABLE_; DAC_CALLBACK_MODE=false; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samd21/source; ../../../../system/interrupt; ../../..; ../../../../port; ../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../../utils/preprocessor; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../sercom; ../../../../system/power; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../system/reset; ../../../../system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../events/events_sam_d_r_h; ../../../../rtc/rtc_sam_d_r_h; ../../../../../boards/samd21_xplained_pro; ../../../../../utils/cmsis/samd21/include; ../../../dac_sam_d_c_h; ../../../../rtc; ../../../../system/power/power_sam_d_r_h; ../../../../../../common2/services/delay/sam0; ..; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../..; ../../../../events; ../../../../../utils/header_files; ../../../../system/interrupt/system_interrupt_samd21; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_unit_test_flash.bin
  ILINK.IlinkOutputFile: dac_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../rtc/rtc_sam_d_r_h/: rtc_count.c
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_common.h events_hooks.h events.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../events/events_sam_d_r_h/: events.c
  group sam0/drivers/dac
    ../../../: dac.h
  group sam0/drivers/dac/unit_test
    ../../: unit_test.c
  group sam0/drivers/dac/unit_test/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/dac/unit_test/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../dac_sam_d_c_h/: dac.c dac_feature.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../utils/cmsis/samd21/include/: samd21g15b.h samd21e17l.h samd21g17l.h samd21g18au.h samd21e15a.h samd21e17d.h samd21e16l.h samd21g17d.h samd21g17a.h samd21g15a.h samd21e16a.h samd21j16b.h samd21g17au.h samd21.h samd21g16a.h samd21j17d.h samd21e18a.h samd21g18a.h samd21j15a.h samd21j18a.h samd21e16b.h samd21e15l.h samd21e16bu.h samd21j15b.h samd21e17a.h samd21g16b.h samd21j16a.h samd21e15b.h samd21g15l.h samd21e15bu.h samd21j17a.h samd21e17du.h samd21g16l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../utils/cmsis/samd21/include/pio/: samd21e18a.h samd21j15b.h samd21e17d.h samd21g17l.h samd21e15b.h samd21g17au.h samd21g15l.h samd21j17a.h samd21j15a.h samd21g16l.h samd21g16b.h samd21e16b.h samd21j16a.h samd21g17d.h samd21j17d.h samd21e17l.h samd21j18a.h samd21g18au.h samd21g15a.h samd21e16a.h samd21e16bu.h samd21g18a.h samd21e15bu.h samd21e17du.h samd21e15a.h samd21g15b.h samd21j16b.h samd21e17a.h samd21g16a.h samd21e15l.h samd21g17a.h samd21e16l.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../utils/cmsis/samd21/include/instance/: usb.h dsu.h eic.h ac1.h gclk.h nvmctrl_variant_d.h sbmatrix.h pac0.h tc4.h tc6.h port.h pm.h ac.h tcc1.h tc3.h pac2.h sercom4.h sercom2.h evsys.h tcc3.h evsys_variant_d.h tc5.h tc7.h wdt.h sercom1.h rtc.h tcc0.h dmac.h sercom5.h sercom3.h sysctrl.h sercom0.h i2s.h tcc2.h dac.h adc.h port_variant_d.h pac1.h nvmctrl.h mtb.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../utils/cmsis/samd21/include/component/: tcc.h sysctrl.h tcc_lighting.h gclk.h dsu.h dmac.h wdt.h rtc.h sercom.h evsys.h usb.h tc.h hmatrixb.h tcc_variant_d.h pac.h mtb.h dac.h evsys_variant_d.h port.h i2s.h nvmctrl_variant_d.h adc.h pm_variant_d.h pm.h nvmctrl.h ac.h eic.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
