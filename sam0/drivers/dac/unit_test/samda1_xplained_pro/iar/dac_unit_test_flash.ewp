# IAR project dac_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; _ASSERT_ENABLE_; DAC_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../..; ../../../../port; ../../../../system/reset; ../../../../../utils/preprocessor; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../sercom; ../../../../system/power; ../../../../../boards; ../../../../sercom/usart; ../../../../../utils/cmsis/samda1/include; ..; ../../../../../../common/services/serial; ../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../rtc; ../../../../../../common/utils; ../../../../events/events_sam_d_r_h; ../../../../rtc/rtc_sam_d_r_h; ../../../../system/interrupt; ../../../dac_sam_d_c_h; ../../../../system/reset/reset_sam_d_r_h; ../../../../../boards/samda1_xplained_pro; ../../../../system/interrupt/system_interrupt_samda; ../../../../../../common2/services/delay/sam0; ../../../../system/power/power_sam_d_r_h; ../../../../../utils/cmsis/samda1/source; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../..; ../../../../events; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_unit_test_flash.bin
  ILINK.IlinkOutputFile: dac_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../rtc/rtc_sam_d_r_h/: rtc_count.c
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../events/events_sam_d_r_h/: events.c
  group sam0/drivers/dac
    ../../../: dac.h
  group sam0/drivers/dac/unit_test
    ../../: unit_test.c
  group sam0/drivers/dac/unit_test/samda1_xplained_pro
    ../: conf_test.h conf_board.h conf_clocks.h
  group sam0/drivers/dac/unit_test/samda1_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../dac_sam_d_c_h/: dac.c dac_feature.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../utils/cmsis/samda1/include/: samda1j15a.h samda1j16a.h samda1g16a.h samda1.h samda1j15b.h samda1g14a.h samda1e14a.h samda1g16b.h samda1j14b.h samda1g15a.h samda1e14b.h samda1e16a.h samda1j16b.h samda1e15b.h samda1g14b.h samda1g15b.h samda1e15a.h samda1j14a.h samda1e16b.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../utils/cmsis/samda1/include/instance/: tc3.h pac0.h pac2.h port.h eic.h tc6.h rtc.h mtb.h sbmatrix.h pm.h tcc1.h ac.h pac1.h tc5.h tcc2.h sysctrl.h tc4.h dmac.h i2s.h sercom1.h sercom3.h tc7.h usb.h sercom4.h evsys.h dac.h adc.h sercom0.h nvmctrl.h sercom2.h gclk.h sercom5.h dsu.h wdt.h tcc0.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../utils/cmsis/samda1/include/component/: pac.h wdt.h pm.h gclk.h nvmctrl.h ac.h hmatrixb.h dsu.h i2s.h port.h tc.h evsys.h eic.h tcc.h sercom.h dmac.h usb.h rtc.h dac.h adc.h mtb.h sysctrl.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../utils/cmsis/samda1/include/pio/: samda1j15b.h samda1e16b.h samda1e14b.h samda1e15b.h samda1j14a.h samda1e14a.h samda1g15a.h samda1g14a.h samda1g16b.h samda1j14b.h samda1e16a.h samda1g16a.h samda1e15a.h samda1g15b.h samda1j16b.h samda1g14b.h samda1j16a.h samda1j15a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
