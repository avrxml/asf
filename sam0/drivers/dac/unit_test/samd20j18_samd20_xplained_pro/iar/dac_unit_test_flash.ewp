# IAR project dac_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; _ASSERT_ENABLE_; DAC_CALLBACK_MODE=false; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../..; ../../../../system/clock/clock_samd20; ../../../../port; ../../../../system/reset; ../../../../../utils/preprocessor; ../../../../../boards/samd20_xplained_pro; ../../../../../utils/cmsis/samd20/source; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../sercom; ../../../../system/power; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../rtc; ../../../../../../common/utils; ../../../../events/events_sam_d_r_h; ../../../../system/interrupt/system_interrupt_samd20; ../../../../system/interrupt; ../../../dac_sam_d_c_h; ../../../../system/reset/reset_sam_d_r_h; ../../../../../../common2/services/delay/sam0; ..; ../../../../system/power/power_sam_d_r_h; ../../../../../../common/boards; ../../../../../utils/cmsis/samd20/include; ../../../../system/pinmux; ../../../../system; ../..; ../../../../rtc/rtc_sam_d_r_h; ../../../../events; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_unit_test_flash.bin
  ILINK.IlinkOutputFile: dac_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../system/clock/clock_samd20/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../rtc/rtc_sam_d_r_h/: rtc_count.c
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../events/events_sam_d_r_h/: events.c
  group sam0/drivers/dac
    ../../../: dac.h
  group sam0/drivers/dac/unit_test
    ../../: unit_test.c
  group sam0/drivers/dac/unit_test/samd20j18_samd20_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/dac/unit_test/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../dac_sam_d_c_h/: dac.c dac_feature.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../utils/cmsis/samd20/include/: samd20j14.h samd20g18u.h samd20g14b.h samd20j16b.h samd20j16.h samd20.h samd20g16b.h samd20j18.h samd20j17.h samd20g18.h samd20e17.h samd20j14b.h samd20g17u.h samd20e15.h samd20e16b.h samd20g17.h samd20g15b.h samd20e16.h samd20e14b.h samd20e15b.h samd20g15.h samd20e14.h samd20j15b.h samd20g16.h samd20e18.h samd20j15.h samd20g14.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../utils/cmsis/samd20/include/pio/: samd20e15.h samd20j15.h samd20j16b.h samd20j17.h samd20e17.h samd20j15b.h samd20e16b.h samd20j16.h samd20g18.h samd20g15b.h samd20g16b.h samd20e18.h samd20j14.h samd20g18u.h samd20j18.h samd20g14.h samd20g16.h samd20g15.h samd20g14b.h samd20e15b.h samd20g17.h samd20g17u.h samd20e16.h samd20j14b.h samd20e14.h samd20e14b.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../utils/cmsis/samd20/include/component/: dac.h adc.h port.h wdt.h sysctrl.h evsys.h pm.h pac.h dsu.h ac.h eic.h tc.h sercom.h rtc.h nvmctrl.h gclk.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../utils/cmsis/samd20/include/instance/: pac1.h sercom5.h sercom0.h sysctrl.h sercom3.h dsu.h pm.h dac.h ac.h sercom4.h adc.h sercom2.h tc7.h rtc.h tc3.h tc1.h pac2.h nvmctrl.h evsys.h tc5.h wdt.h port.h tc6.h gclk.h pac0.h tc0.h eic.h sercom1.h tc4.h tc2.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
