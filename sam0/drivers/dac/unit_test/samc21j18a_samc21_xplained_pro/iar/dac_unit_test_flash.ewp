# IAR project dac_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; BOARD=SAMC21_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; _ASSERT_ENABLE_; DAC_CALLBACK_MODE=false; __SAMC21J18A__
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/cmsis/samc21/include; ../../../../port; ../../../../system/reset; ../../../../../utils/cmsis/samc21/source; ../../../../rtc/rtc_sam_l_c; ../../../../../utils/preprocessor; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../sercom; ../../../../system/power; ../../../../../boards; ../../../../system/interrupt/system_interrupt_samc20_c21; ../../../../../../common/services/serial; ../../../../events/events_sam_l_c; ../../../../rtc; ../../../../../../common/utils; ../../../../system/interrupt; ../../../dac_sam_d_c_h; ../../../../system/power/power_sam_c; ../../../../../../common2/services/delay/sam0; ../../../../system/clock/clock_samc20_c21; ../../../../system/reset/reset_sam_c; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../sercom/usart; ../../../../system; ../..; ..; ../../../../events; ../../../../../utils/header_files; ../../../../../boards/samc21_xplained_pro; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_unit_test_flash.bin
  ILINK.IlinkOutputFile: dac_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../system/clock/clock_samc20_c21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../system/reset/reset_sam_c/: reset.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../system/power/power_sam_c/: power.h
  group sam0/drivers/dac
    ../../../: dac.h
  group sam0/drivers/dac/unit_test
    ../../: unit_test.c
  group sam0/drivers/dac/unit_test/samc21j18a_samc21_xplained_pro
    ../: conf_rtc.h conf_test.h conf_board.h conf_clocks.h
  group sam0/drivers/dac/unit_test/samc21j18a_samc21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../dac_sam_d_c_h/: dac.c dac_feature.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../rtc/rtc_sam_l_c/: rtc_count.c
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_common.h events_hooks.h events.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../events/events_sam_l_c/: events.c
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../utils/cmsis/samc21/include/: samc21g15a.h samc21g17a.h samc21.h samc21e15a.h samc21j18a.h samc21g18a.h samc21e16a.h samc21e18a.h samc21g16a.h samc21j17a.h samc21e17a.h samc21j15a.h samc21j16a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../utils/cmsis/samc21/include/instance/: pm.h wdt.h dmac.h tcc0.h adc1.h rstc.h sercom2.h supc.h can1.h sercom0.h tsens.h evsys.h eic.h gclk.h dsu.h tal.h oscctrl.h tc3.h tcc1.h port.h freqm.h dac.h divas.h osc32kctrl.h pac.h tc2.h mclk.h tc0.h mtb.h ac.h sercom5.h tc4.h sercom3.h can0.h sercom1.h adc0.h ccl.h tcc2.h sercom4.h nvmctrl.h tc1.h sdadc.h rtc.h hmatrixhs.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../utils/cmsis/samc21/include/component/: gclk.h tc.h evsys.h ccl.h pac.h divas.h ac.h tal.h supc.h nvmctrl.h sercom.h adc.h tsens.h sdadc.h mtb.h port.h osc32kctrl.h freqm.h dsu.h dac.h rstc.h mclk.h can.h eic.h wdt.h hmatrixb.h tcc.h dmac.h oscctrl.h rtc.h pm.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../utils/cmsis/samc21/include/pio/: samc21j18a.h samc21j15a.h samc21j17a.h samc21e15a.h samc21e16a.h samc21g16a.h samc21g17a.h samc21g15a.h samc21e18a.h samc21j16a.h samc21e17a.h samc21g18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samc21_xplained_pro
    ../../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
