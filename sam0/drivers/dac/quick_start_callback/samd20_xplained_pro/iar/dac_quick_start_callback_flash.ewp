# IAR project dac_quick_start_callback_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; RTC_COUNT_ASYNC=true; BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; DAC_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../..; ../../../../system/clock/clock_samd20; ../../../../port; ../../../../../utils/preprocessor; ../../../../../boards/samd20_xplained_pro; ../../../../../utils/cmsis/samd20/source; ../../../../../utils; ../../../../../boards; ../..; ../../../../rtc; ../../../../../../common/utils; ../../../../system/interrupt/system_interrupt_samd20; ../../../../system/interrupt; ..; ../../../../../utils/cmsis/samd20/include/component; ../../../../../utils/cmsis/samd20/include/pio; ../../../../../../common/boards; ../../../../../utils/cmsis/samd20/include; ../../../../system/pinmux; ../../../../../utils/cmsis/samd20/include/instance; ../../../../system; ../../../../events; ../../../../../utils/header_files; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_quick_start_callback_flash.bin
  ILINK.IlinkOutputFile: dac_quick_start_callback_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../utils/cmsis/samd20/include/: samd20j14.h samd20j16.h samd20.h samd20j18.h samd20j17.h samd20g18.h samd20e17.h samd20e15.h samd20g17.h samd20e16.h samd20j15.h samd20g15.h samd20e14.h samd20g16.h samd20g14.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../utils/cmsis/samd20/include/pio/: pio_samd20e17.h pio_samd20e15.h pio_samd20j18.h pio_samd20g14.h pio_samd20g16.h pio_samd20e14.h pio_samd20e16.h pio_samd20j14.h pio_samd20j16.h pio_samd20g18.h pio_samd20j15.h pio_samd20j17.h pio_samd20g15.h pio_samd20e1f.h pio_samd20g17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../utils/cmsis/samd20/include/instance/: instance_sercom4.h instance_gclk.h instance_nvmctrl.h instance_dsu.h instance_sysctrl.h instance_ac.h instance_rtc.h instance_pac0.h instance_pac2.h instance_sercom5.h instance_port.h instance_dac.h instance_sercom3.h instance_evsys.h instance_sercom1.h instance_pac1.h instance_wdt.h instance_eic.h instance_tc3.h instance_tc1.h instance_adc.h instance_sercom2.h instance_tc5.h instance_tc6.h instance_sercom0.h instance_tc2.h instance_tc7.h instance_tc0.h instance_pm.h instance_tc4.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../utils/cmsis/samd20/include/component/: component_dsu.h component_ac.h component_wdt.h component_evsys.h component_pac.h component_eic.h component_port.h component_gclk.h component_sercom.h component_tc.h component_dac.h component_nvmctrl.h component_pm.h component_rtc.h component_sysctrl.h component_adc.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/dac
    ../../../: dac.c dac_callback.c dac_callback.h dac.h
  group sam0/drivers/dac/quick_start_callback
    ../../: qs_dac_callback.c
  group sam0/drivers/dac/quick_start_callback/samd20_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/dac/quick_start_callback/samd20_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_count_interrupt.c rtc_count.c rtc_count.h rtc_count_interrupt.h
  group sam0/drivers/rtc/quick_start_count_callback
    ../../../../rtc/quick_start_count_callback/: qs_rtc_count_callback.h
  group sam0/drivers/rtc/quick_start_count
    ../../../../rtc/quick_start_count/: qs_rtc_count_basic.h
  group sam0/drivers/events
    ../../../../events/: events.c events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../../events/quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/events/quick_start
    ../../../../events/quick_start/: qs_events_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
