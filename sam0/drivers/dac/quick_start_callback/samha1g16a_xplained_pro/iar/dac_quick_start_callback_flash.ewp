# IAR project dac_quick_start_callback_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: RTC_COUNT_ASYNC=true; EVENTS_INTERRUPT_HOOKS_MODE=true; BOARD=SAMHA1G16A_XPLAINED_PRO; DAC_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; __SAMHA1G16A__
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/cmsis/samha1/include; ../../../../port; ../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../utils/cmsis/samha1/source; ../../../../system/power; ../../../../../boards; ../..; ../../../../system/reset; ../../../../system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../events/events_sam_d_r_h; ../../../../rtc/rtc_sam_d_r_h; ../../../../system/interrupt; ../../../dac_sam_d_c_h; ../../../../rtc; ..; ../../../../system/interrupt/system_interrupt_samha; ../../../../system/power/power_sam_d_r_h; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../../../../events; ../../../../../utils/header_files; ../../../../../boards/samha1g16a_xplained_pro; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_quick_start_callback_flash.bin
  ILINK.IlinkOutputFile: dac_quick_start_callback_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../events/events_sam_d_r_h/: events.c
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samha
    ../../../../system/interrupt/system_interrupt_samha/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/dac
    ../../../: dac.h dac_callback.h
  group sam0/drivers/dac/quick_start_callback
    ../../: qs_dac_callback.c
  group sam0/drivers/dac/quick_start_callback/samha1g16a_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/dac/quick_start_callback/samha1g16a_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../dac_sam_d_c_h/: dac.c dac_callback.c dac_feature.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_tamper.h rtc_count.h rtc_count_interrupt.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../rtc/rtc_sam_d_r_h/: rtc_count.c rtc_count_interrupt.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../utils/cmsis/samha1/include/: samha1g15ab.h samha1g14a.h samha1e14a.h samha1.h samha1g14ab.h samha1g16ab.h samha1e14ab.h samha1e16ab.h samha1e15ab.h samha1g15a.h samha1e15a.h samha1e16a.h samha1g16a.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../utils/cmsis/samha1/include/instance/: sercom5.h adc.h sercom4.h port.h wdt.h sysctrl.h evsys.h tc7.h pm.h sercom1.h sbmatrix.h nvmctrl.h sercom3.h tcc0.h dmac.h tcc2.h tc3.h tc5.h dsu.h dac.h ac.h pac0.h tc6.h eic.h sercom0.h pac2.h tcc1.h sercom2.h tc4.h linctrl.h pac1.h rtc.h gclk.h mtb.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../utils/cmsis/samha1/include/component/: hmatrixb.h mtb.h evsys.h gclk.h sercom.h tc.h pm.h port.h tcc.h eic.h rtc.h ac.h dac.h adc.h wdt.h pac.h sysctrl.h nvmctrl.h dsu.h dmac.h linctrl.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../utils/cmsis/samha1/include/pio/: samha1e14a.h samha1g16ab.h samha1e16ab.h samha1e14ab.h samha1g15ab.h samha1e15ab.h samha1e16a.h samha1g16a.h samha1g14a.h samha1e15a.h samha1g15a.h samha1g14ab.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
