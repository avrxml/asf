# IAR project wdt_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; SYSTICK_MODE; _ASSERT_ENABLE_; WDT_CALLBACK_MODE=true; __SAMR21G18A__; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../system/clock/clock_samd21_r21; ../../../../port; ../../../../system/interrupt/system_interrupt_samr21; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/samr21/source; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../sercom; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../..; ../../../../../../common/utils; ../../../../system/interrupt; ..; ../../../../../../common2/services/delay/sam0; ../../../../../boards/samr21_xplained_pro; ../../../../../utils/cmsis/samr21/include; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../..; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wdt_unit_test_flash.bin
  ILINK.IlinkOutputFile: wdt_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/samr21_xplained_pro
    ../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../utils/cmsis/samr21/include/: samr21g17a.h samr21e17a.h samr21e16a.h samr21e18a.h samr21.h samr21g16a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../utils/cmsis/samr21/include/instance/: dac.h port.h nvmctrl.h tc3.h sysctrl.h sercom1.h sercom0.h tcc1.h wdt.h gclk.h evsys.h tc6.h pac2.h pac0.h sercom4.h rtc.h sercom2.h sercom3.h mtb.h rfctrl.h eic.h tc7.h tcc2.h ac.h tcc0.h tc4.h sercom5.h usb.h tc5.h dmac.h adc.h pac1.h i2s.h pm.h dsu.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../utils/cmsis/samr21/include/pio/: samr21e16a.h samr21e17a.h samr21g17a.h samr21g16a.h samr21e18a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../utils/cmsis/samr21/include/component/: eic.h evsys.h mtb.h adc.h rfctrl.h gclk.h sysctrl.h tcc.h i2s.h ac.h pm.h dmac.h rtc.h pac.h port.h dsu.h wdt.h nvmctrl.h usb.h tc.h dac.h sercom.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/wdt
    ../../../: wdt_callback.c wdt.c wdt_callback.h wdt.h
  group sam0/drivers/wdt/unit_tests
    ../../: unit_test.c
  group sam0/drivers/wdt/unit_tests/samr21g18a_samr21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/wdt/unit_tests/samr21g18a_samr21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/wdt/quick_start
    ../../../quick_start/: qs_wdt_basic.h
  group sam0/drivers/wdt/quick_start_callback
    ../../../quick_start_callback/: qs_wdt_callback.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
