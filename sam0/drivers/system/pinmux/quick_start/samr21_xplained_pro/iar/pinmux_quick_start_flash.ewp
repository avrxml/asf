# IAR project pinmux_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__
  ICCARM.CCIncludePath2: ../../../../interrupt; ../../../../../../boards/samr21_xplained_pro; ../../../../../../utils/cmsis/samr21/include; ../../../../../../utils; ../../../../../port; ../../../../../../boards; ../../../../../../utils/cmsis/samr21/include/instance; ../../../../../../../common/boards; ../../../../clock/clock_samd21_r21; ../../..; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/samr21/include/component; ..; ../../../../../../utils/cmsis/samr21/source; ../../../../interrupt/system_interrupt_samr21; ../../../../../../utils/header_files; ../../../../../../../common/utils; ../..; ../../../../../../utils/cmsis/samr21/include/pio; ../../../..; ../../../../clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pinmux_quick_start_flash.bin
  ILINK.IlinkOutputFile: pinmux_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../utils/cmsis/samr21/include/: samr21e18a.h samr21.h samr21g16a.h samr21e16a.h samr21e17a.h samr21g17a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../utils/cmsis/samr21/include/instance/: instance_tc7.h instance_dmac.h instance_tcc0.h instance_rtc.h instance_evsys.h instance_tc5.h instance_tc3.h instance_tcc2.h instance_tc6.h instance_ac.h instance_gclk.h instance_sercom5.h instance_tcc1.h instance_sercom4.h instance_dsu.h instance_tc4.h instance_pm.h instance_usb.h instance_mtb.h instance_sysctrl.h instance_rfctrl.h instance_sercom1.h instance_eic.h instance_sercom3.h instance_pac2.h instance_i2s.h instance_pac0.h instance_adc.h instance_dac.h instance_sercom0.h instance_nvmctrl.h instance_sercom2.h instance_wdt.h instance_port.h instance_pac1.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../utils/cmsis/samr21/include/component/: component_sysctrl.h component_gclk.h component_pm.h component_dsu.h component_ac.h component_adc.h component_port.h component_evsys.h component_dac.h component_rtc.h component_rfctrl.h component_wdt.h component_dmac.h component_sercom.h component_eic.h component_nvmctrl.h component_pac.h component_mtb.h component_i2s.h component_tcc.h component_usb.h component_tc.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../utils/cmsis/samr21/include/pio/: pio_samr21e17a.h pio_samr21g16a.h pio_samr21g17a.h pio_samr21e18a.h pio_samr21g18a.h pio_samr21e16a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/clock
    ../../../../clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/pinmux
    ../../../: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../: qs_pinmux_basic.c qs_pinmux_basic.h
  group sam0/drivers/system/pinmux/quick_start/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/pinmux/quick_start/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
