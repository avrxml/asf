# IAR project clock_quick_start_clock_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMHA1G16A_XPLAINED_PRO; __SAMHA1G16A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samha1/include; ../../../../power; ../../../clock_samd21_r21_da_ha1; ../../../../../../utils/preprocessor; ../..; ../../../../../../utils/cmsis/samha1/source; ../../../../../../utils; ../../../../../port; ../../../../../../boards; ../../../../reset; ../../../../reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../interrupt; ..; ../../../../interrupt/system_interrupt_samha; ../../../../power/power_sam_d_r_h; ../../../../../../../common/boards; ../../../../pinmux; ../../../..; ../../../../../../utils/header_files; ../../../../../../boards/samha1g16a_xplained_pro; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_quick_start_clock_flash.bin
  ILINK.IlinkOutputFile: clock_quick_start_clock_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samha
    ../../../../interrupt/system_interrupt_samha/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../: qs_clock_source.c
  group sam0/drivers/system/clock/quick_start_clock/samha1g16a_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/clock/quick_start_clock/samha1g16a_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../../utils/cmsis/samha1/include/: samha1.h samha1g14a.h samha1e14ab.h samha1g16ab.h samha1g14ab.h samha1e15ab.h samha1g15ab.h samha1e14a.h samha1e16a.h samha1g15a.h samha1e15a.h samha1g16a.h samha1e16ab.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../../utils/cmsis/samha1/include/instance/: gclk.h nvmctrl.h tc6.h tcc0.h tcc2.h dsu.h linctrl.h tc4.h mtb.h dac.h sercom4.h tc7.h pac2.h dmac.h sercom2.h tc3.h sbmatrix.h adc.h sercom0.h tc5.h evsys.h sercom5.h wdt.h sysctrl.h ac.h sercom3.h sercom1.h pac0.h pm.h eic.h tcc1.h pac1.h port.h rtc.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../../utils/cmsis/samha1/include/component/: wdt.h evsys.h adc.h linctrl.h rtc.h dmac.h port.h eic.h pm.h dsu.h gclk.h pac.h tc.h hmatrixb.h tcc.h sercom.h mtb.h nvmctrl.h sysctrl.h ac.h dac.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../../utils/cmsis/samha1/include/pio/: samha1e14ab.h samha1g16a.h samha1e16ab.h samha1e15a.h samha1g14a.h samha1g15a.h samha1e16a.h samha1g15ab.h samha1g14ab.h samha1g16ab.h samha1e15ab.h samha1e14a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
