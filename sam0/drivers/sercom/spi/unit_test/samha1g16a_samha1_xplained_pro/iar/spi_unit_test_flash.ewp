# IAR project spi_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAMHA1G16A_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMHA1G16A__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samha1/include; ../../../../../system/power; ../../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../../../utils/preprocessor; ../../..; ../../../../../../utils/cmsis/samha1/source; ../../../../../../utils; ../../../..; ../../../../../port; ../../../../../../boards; ..; ../../../../usart; ../../../../../../../common/services/serial; ../../../../../system/reset; ../../../../../system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../../system/interrupt; ../..; ../../../../../../utils/stdio/stdio_serial; ../../../../../system/interrupt/system_interrupt_samha; ../../../../../system/power/power_sam_d_r_h; ../../../../../../../common/boards; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/header_files; ../../../../../../boards/samha1g16a_xplained_pro; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_unit_test_flash.bin
  ILINK.IlinkOutputFile: spi_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../../utils/cmsis/samha1/include/: samha1g15ab.h samha1.h samha1g14a.h samha1e14ab.h samha1g16ab.h samha1g14ab.h samha1e15ab.h samha1e14a.h samha1e16a.h samha1g15a.h samha1e15a.h samha1e16ab.h samha1g16a.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../../utils/cmsis/samha1/include/instance/: gclk.h ac.h tc6.h tcc0.h tcc2.h dsu.h linctrl.h tc4.h mtb.h dac.h sercom4.h tc7.h pac2.h dmac.h pac0.h sercom2.h tc3.h sbmatrix.h adc.h sercom0.h tc5.h evsys.h sercom5.h wdt.h sysctrl.h nvmctrl.h sercom3.h sercom1.h pm.h eic.h tcc1.h pac1.h port.h rtc.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../../utils/cmsis/samha1/include/component/: wdt.h evsys.h adc.h linctrl.h pac.h rtc.h dmac.h dsu.h port.h eic.h pm.h gclk.h tc.h hmatrixb.h tcc.h sercom.h mtb.h nvmctrl.h sysctrl.h ac.h dac.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../../utils/cmsis/samha1/include/pio/: samha1e15a.h samha1e14ab.h samha1g16a.h samha1e16ab.h samha1g15a.h samha1g14a.h samha1e16a.h samha1g15ab.h samha1g14ab.h samha1g16ab.h samha1e15ab.h samha1e14a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/drivers/sercom
    ../../../../: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/spi
    ../../../: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/unit_test
    ../../: unit_test.c
  group sam0/drivers/sercom/spi/unit_test/samha1g16a_samha1_xplained_pro
    ../: conf_board.h conf_test.h conf_spi.h conf_clocks.h
  group sam0/drivers/sercom/spi/unit_test/samha1g16a_samha1_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/usart
    ../../../../usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samha
    ../../../../../system/interrupt/system_interrupt_samha/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
