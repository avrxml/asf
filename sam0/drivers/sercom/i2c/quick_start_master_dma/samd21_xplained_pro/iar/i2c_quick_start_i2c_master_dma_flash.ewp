# IAR project i2c_quick_start_i2c_master_dma_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; __SAMD21J18A__; I2C_MASTER_CALLBACK_MODE=false; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..; ../../../../../../utils/cmsis/samd21/source; ../../../../../system/clock/clock_samd21_r21; ../../../../../port; ../../../../../../utils/preprocessor; ../../../../../dma; ../../../../../../utils; ../../../..; ../../../../../../boards; ../../..; ../../../i2c_samd21_r21_d10_d11; ../../../../../system/interrupt; ../../../../../../../common/utils; ../../../../../system/interrupt/system_interrupt_samd21; ../../../../../../utils/cmsis/samd21/include; ../..; ../../../../../../../common/boards; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/header_files; ../../../../../../boards/samd21_xplained_pro; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_quick_start_i2c_master_dma_flash.bin
  ILINK.IlinkOutputFile: i2c_quick_start_i2c_master_dma_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../system/clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../: i2c_common.h i2c_master.h
  group sam0/drivers/sercom/i2c/i2c_samd21_r21_d10_d11
    ../../../i2c_samd21_r21_d10_d11/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../: qs_i2c_master_dma.c qs_i2c_master_dma.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma/samd21_xplained_pro
    ../: conf_board.h conf_dma.h conf_clocks.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/dma
    ../../../../../dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../../dma/quick_start/: qs_dma_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../utils/cmsis/samd21/include/: samd21e17a.h samd21e15a.h samd21g15a.h samd21.h samd21j15a.h samd21j17a.h samd21g16a.h samd21j16a.h samd21g18a.h samd21e18a.h samd21e16a.h samd21j18a.h samd21g17a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../utils/cmsis/samd21/include/instance/: tc6.h pac0.h sercom4.h tc5.h wdt.h tc7.h gclk.h nvmctrl.h sercom5.h sercom1.h ac.h dsu.h sercom3.h pac1.h pm.h tcc1.h i2s.h tc4.h port.h usb.h tcc0.h evsys.h sercom2.h eic.h tcc2.h sercom0.h pac2.h dmac.h dac.h rtc.h tc3.h adc.h sysctrl.h mtb.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../utils/cmsis/samd21/include/component/: dac.h ac.h nvmctrl.h sercom.h pac.h tcc.h port.h sysctrl.h mtb.h evsys.h gclk.h pm.h usb.h eic.h rtc.h tc.h dmac.h wdt.h i2s.h adc.h dsu.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../utils/cmsis/samd21/include/pio/: samd21e15a.h samd21j15a.h samd21j16a.h samd21g15a.h samd21j17a.h samd21e18a.h samd21g17a.h samd21j18a.h samd21e16a.h samd21e17a.h samd21g18a.h samd21g16a.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
