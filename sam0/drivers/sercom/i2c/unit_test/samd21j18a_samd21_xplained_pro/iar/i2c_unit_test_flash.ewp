# IAR project i2c_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; I2C_SLAVE_CALLBACK_MODE=true; BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD21J18A__; I2C_MASTER_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samd21/source; ../../../../../system/interrupt; ../../../../../system/power; ../../../../../system/clock/clock_samd21_r21_da_ha1; ../../../i2c_sam0; ../../../../../../utils/preprocessor; ../..; ../../../../../../../common2/services/delay; ../../../../../../utils; ..; ../../../..; ../../../../../port; ../../../../../../boards; ../../../../usart; ../../../../../../../common/services/serial; ../../..; ../../../../../system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../../../boards/samd21_xplained_pro; ../../../../../../utils/cmsis/samd21/include; ../../../../../../../common2/services/delay/sam0; ../../../../../system/power/power_sam_d_r_h; ../../../../../../../common/boards; ../../../../../system/pinmux; ../../../../../system; ../../../../../system/reset; ../../../../../../utils/header_files; ../../../../../system/interrupt/system_interrupt_samd21; ../../../../../../utils/stdio/stdio_serial; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_unit_test_flash.bin
  ILINK.IlinkOutputFile: i2c_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_interrupt.h sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../: i2c_master_interrupt.h i2c_common.h i2c_master.h i2c_slave_interrupt.h i2c_slave.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../i2c_sam0/: i2c_slave_interrupt.c i2c_slave.c i2c_master_interrupt.c i2c_master.c
  group sam0/drivers/sercom/i2c/unit_test
    ../../: unit_test.c
  group sam0/drivers/sercom/i2c/unit_test/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/sercom/i2c/unit_test/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/i2c/quick_start_master_callback
    ../../../quick_start_master_callback/: qs_i2c_master_callback.h
  group sam0/drivers/sercom/i2c/quick_start_slave_dma
    ../../../quick_start_slave_dma/: qs_i2c_slave_dma.h
  group sam0/drivers/sercom/i2c/quick_start_slave
    ../../../quick_start_slave/: qs_i2c_slave_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_slave_callback
    ../../../quick_start_slave_callback/: qs_i2c_slave_callback.h
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/sercom/usart
    ../../../../usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../utils/cmsis/samd21/include/: samd21e17a.h samd21g16l.h samd21e15a.h samd21e15l.h samd21g15l.h samd21g17l.h samd21e15b.h samd21j17d.h samd21e17d.h samd21g15a.h samd21e17du.h samd21.h samd21g16b.h samd21e16a.h samd21j15a.h samd21g18a.h samd21g17a.h samd21e16b.h samd21j17a.h samd21g16a.h samd21e17l.h samd21g15b.h samd21j16a.h samd21e18a.h samd21e16bu.h samd21g17au.h samd21j16b.h samd21j18a.h samd21e16l.h samd21j15b.h samd21g18au.h samd21g17d.h samd21e15bu.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../utils/cmsis/samd21/include/instance/: tc6.h pac0.h sercom4.h tc5.h wdt.h tc4.h pac2.h tc7.h sbmatrix.h gclk.h nvmctrl.h sercom5.h sercom1.h ac.h dsu.h sercom3.h pac1.h pm.h tcc1.h i2s.h usb.h port.h ac1.h evsys_variant_d.h tcc0.h evsys.h sercom2.h eic.h nvmctrl_variant_d.h tcc2.h sercom0.h dmac.h dac.h rtc.h tc3.h adc.h port_variant_d.h tcc3.h sysctrl.h mtb.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../utils/cmsis/samd21/include/pio/: samd21e16b.h samd21g16l.h samd21e15a.h samd21j17d.h samd21e15bu.h samd21j15a.h samd21g15b.h samd21e15l.h samd21e17d.h samd21g15a.h samd21g17l.h samd21j16b.h samd21j15b.h samd21e16l.h samd21e15b.h samd21g16a.h samd21g15l.h samd21g16b.h samd21j17a.h samd21e18a.h samd21g18au.h samd21g17a.h samd21j18a.h samd21e16a.h samd21e17a.h samd21j16a.h samd21g18a.h samd21e17du.h samd21g17au.h samd21g17d.h samd21e16bu.h samd21e17l.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../utils/cmsis/samd21/include/component/: dac.h ac.h nvmctrl.h sercom.h usb.h pac.h tcc.h port.h sysctrl.h i2s.h mtb.h evsys.h gclk.h pm.h hmatrixb.h eic.h rtc.h nvmctrl_variant_d.h evsys_variant_d.h tcc_variant_d.h tc.h tcc_lighting.h dmac.h wdt.h pm_variant_d.h adc.h dsu.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
