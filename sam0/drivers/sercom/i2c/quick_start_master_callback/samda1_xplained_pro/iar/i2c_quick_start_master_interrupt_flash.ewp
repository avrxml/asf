# IAR project i2c_quick_start_master_interrupt_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAMDA1J16A__; I2C_MASTER_CALLBACK_MODE=true; BOARD=SAMDA1_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../system/power; ../../../../../system/clock/clock_samd21_r21_da_ha1; ../../../i2c_sam0; ..; ../../../../../../utils/preprocessor; ../..; ../../../../../../utils; ../../../..; ../../../../../port; ../../../../../../boards; ../../../../../../utils/cmsis/samda1/include; ../../..; ../../../../../system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../../system/interrupt; ../../../../../../boards/samda1_xplained_pro; ../../../../../system/interrupt/system_interrupt_samda; ../../../../../system/power/power_sam_d_r_h; ../../../../../../utils/cmsis/samda1/source; ../../../../../../../common/boards; ../../../../../system/pinmux; ../../../../../system; ../../../../../system/reset; ../../../../../../utils/header_files; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_quick_start_master_interrupt_flash.bin
  ILINK.IlinkOutputFile: i2c_quick_start_master_interrupt_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/samda1_xplained_pro
    ../../../../../../boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../: i2c_master_interrupt.h i2c_common.h i2c_master.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../i2c_sam0/: i2c_master_interrupt.c i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master_callback
    ../../: qs_i2c_master_callback.c qs_i2c_master_callback.h
  group sam0/drivers/sercom/i2c/quick_start_master_callback/samda1_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/sercom/i2c/quick_start_master_callback/samda1_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../../utils/cmsis/samda1/include/: samda1g16a.h samda1j15a.h samda1j16b.h samda1g15a.h samda1.h samda1e16a.h samda1j14a.h samda1e15a.h samda1g15b.h samda1e14b.h samda1g14b.h samda1j16a.h samda1e14a.h samda1j15b.h samda1g16b.h samda1e15b.h samda1j14b.h samda1g14a.h samda1e16b.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../utils/cmsis/samda1/include/instance/: wdt.h tcc2.h sercom0.h tc7.h tc6.h port.h tcc0.h sercom2.h sercom5.h evsys.h sysctrl.h rtc.h usb.h tc4.h tc3.h sbmatrix.h dac.h sercom3.h mtb.h gclk.h tc5.h eic.h pac1.h sercom1.h dmac.h pm.h ac.h adc.h pac2.h i2s.h tcc1.h pac0.h sercom4.h nvmctrl.h dsu.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../utils/cmsis/samda1/include/component/: sercom.h tcc.h i2s.h ac.h mtb.h wdt.h hmatrixb.h pac.h port.h nvmctrl.h usb.h rtc.h sysctrl.h dmac.h dac.h dsu.h eic.h gclk.h adc.h tc.h evsys.h pm.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../utils/cmsis/samda1/include/pio/: samda1j16a.h samda1j15a.h samda1j15b.h samda1j14a.h samda1g15a.h samda1e16a.h samda1e15b.h samda1j14b.h samda1g15b.h samda1g16a.h samda1e14b.h samda1j16b.h samda1g14b.h samda1e15a.h samda1g14a.h samda1e16b.h samda1e14a.h samda1g16b.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
