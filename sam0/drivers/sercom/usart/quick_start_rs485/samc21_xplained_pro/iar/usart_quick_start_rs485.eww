<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_quick_start_rs485_flash.ewp</path>
	</project>
</workspace>
