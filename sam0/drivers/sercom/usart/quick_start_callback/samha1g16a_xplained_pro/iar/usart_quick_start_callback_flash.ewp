# IAR project usart_quick_start_callback_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMHA1G16A_XPLAINED_PRO; USART_CALLBACK_MODE=true; __SAMHA1G16A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samha1/include; ../../../../../system/power; ../../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../../../utils/cmsis/samha1/source; ../../../..; ../../../../../port; ../../../../../../boards; ../../..; ../../../../../system/reset; ../../../../../system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../../system/interrupt; ../..; ../../../../../system/interrupt/system_interrupt_samha; ../../../../../system/power/power_sam_d_r_h; ..; ../../../../../../../common/boards; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/header_files; ../../../../../../boards/samha1g16a_xplained_pro; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_quick_start_callback_flash.bin
  ILINK.IlinkOutputFile: usart_quick_start_callback_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samha
    ../../../../../system/interrupt/system_interrupt_samha/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/sercom
    ../../../../: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../: usart_interrupt.c usart.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../: qs_usart_callback.c qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_callback/samha1g16a_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/sercom/usart/quick_start_callback/samha1g16a_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../../utils/cmsis/samha1/include/: samha1.h samha1g14a.h samha1e14ab.h samha1g16ab.h samha1g14ab.h samha1e15ab.h samha1g15ab.h samha1e14a.h samha1e16a.h samha1g15a.h samha1e15a.h samha1g16a.h samha1e16ab.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../../utils/cmsis/samha1/include/instance/: gclk.h nvmctrl.h ac.h tc6.h tcc0.h tcc2.h dsu.h sercom5.h linctrl.h tc4.h mtb.h dac.h sercom4.h tc7.h pac2.h dmac.h sercom2.h tc3.h sbmatrix.h adc.h sercom0.h tc5.h evsys.h wdt.h sysctrl.h sercom3.h sercom1.h pac0.h pm.h eic.h tcc1.h pac1.h port.h rtc.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../../utils/cmsis/samha1/include/component/: wdt.h evsys.h adc.h linctrl.h pac.h rtc.h dmac.h port.h eic.h pm.h dsu.h gclk.h tc.h hmatrixb.h tcc.h sercom.h mtb.h nvmctrl.h sysctrl.h ac.h dac.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../../utils/cmsis/samha1/include/pio/: samha1e15a.h samha1e14ab.h samha1g16a.h samha1e16ab.h samha1g15a.h samha1e16a.h samha1g15ab.h samha1g14ab.h samha1g14a.h samha1g16ab.h samha1e15ab.h samha1e14a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
