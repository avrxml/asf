# IAR project tc_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../system/clock/clock_samd20; ../../../../port; ../..; ../../../../../utils/preprocessor; ../../../../../boards/samd20_xplained_pro; ../../../../../utils/cmsis/samd20/source; ../../../../../utils; ../../../../sercom; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../../../common/utils; ../../../../system/interrupt/system_interrupt_samd20; ../../../../system/interrupt; ../../..; ../../../../../utils/cmsis/samd20/include/component; ../../../../../utils/cmsis/samd20/include/pio; ../../../../../../common/boards; ../../../../../utils/cmsis/samd20/include; ../../../../system/pinmux; ../../../../../utils/cmsis/samd20/include/instance; ../../../../system; ../../../../extint; ../../../../events; ..; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tc_unit_test_flash.bin
  ILINK.IlinkOutputFile: tc_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../system/clock/clock_samd20/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/events
    ../../../../events/: events.c events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../../events/quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/events/quick_start
    ../../../../events/quick_start/: qs_events_basic.h
  group sam0/drivers/extint
    ../../../../extint/: extint_callback.c extint.c extint.h extint_callback.h
  group sam0/drivers/extint/quick_start_callback
    ../../../../extint/quick_start_callback/: qs_extint_callback.h
  group sam0/drivers/extint/quick_start_polled
    ../../../../extint/quick_start_polled/: qs_extint_basic.h
  group sam0/drivers/tc
    ../../../: tc.c tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/unit_test
    ../../: unit_test.c
  group sam0/drivers/tc/unit_test/samd20j18_samd20_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group sam0/drivers/tc/unit_test/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/tc/quick_start_dma
    ../../../quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_callback
    ../../../quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start_timer
    ../../../quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start
    ../../../quick_start/: qs_tc_basic.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../utils/cmsis/samd20/include/: samd20j14.h samd20j16.h samd20.h samd20j18.h samd20j17.h samd20g18.h samd20e17.h samd20e15.h samd20g17.h samd20e16.h samd20g15.h samd20e14.h samd20g16.h samd20j15.h samd20g14.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../utils/cmsis/samd20/include/pio/: pio_samd20e17.h pio_samd20e15.h pio_samd20j18.h pio_samd20g14.h pio_samd20g16.h pio_samd20e14.h pio_samd20j15.h pio_samd20e16.h pio_samd20j14.h pio_samd20j16.h pio_samd20g18.h pio_samd20j17.h pio_samd20g15.h pio_samd20e1f.h pio_samd20g17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../utils/cmsis/samd20/include/instance/: instance_sercom4.h instance_gclk.h instance_nvmctrl.h instance_dsu.h instance_sysctrl.h instance_ac.h instance_rtc.h instance_pac0.h instance_pac2.h instance_sercom5.h instance_port.h instance_dac.h instance_sercom3.h instance_evsys.h instance_sercom1.h instance_pac1.h instance_wdt.h instance_eic.h instance_tc3.h instance_tc1.h instance_adc.h instance_sercom2.h instance_tc5.h instance_tc6.h instance_sercom0.h instance_tc2.h instance_tc7.h instance_tc0.h instance_pm.h instance_tc4.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../utils/cmsis/samd20/include/component/: component_dsu.h component_ac.h component_wdt.h component_evsys.h component_pac.h component_eic.h component_port.h component_gclk.h component_sercom.h component_tc.h component_dac.h component_nvmctrl.h component_pm.h component_rtc.h component_sysctrl.h component_adc.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
