# IAR project tc_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD21_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samd21/source; ../../../../system/interrupt; ../../../../system/clock/clock_samd21_r21; ../../../../port; ../..; ../../../../../utils/preprocessor; ../../../../../utils; ..; ../../../../sercom; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../../../common/utils; ../../../../../boards/samd21_xplained_pro; ../../../../../utils/cmsis/samd21/include; ../../..; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../../../../extint; ../../../../events; ../../../../../utils/header_files; ../../../../system/interrupt/system_interrupt_samd21; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tc_unit_test_flash.bin
  ILINK.IlinkOutputFile: tc_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/events
    ../../../../events/: events.c events_hooks.c events_common.h events.h events_hooks.h
  group sam0/drivers/events/quick_start
    ../../../../events/quick_start/: qs_events_basic.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../../events/quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/extint
    ../../../../extint/: extint_callback.c extint.c extint.h extint_callback.h
  group sam0/drivers/tc
    ../../../: tc.c tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/unit_test
    ../../: unit_test.c
  group sam0/drivers/tc/unit_test/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group sam0/drivers/tc/unit_test/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/tc/quick_start_dma
    ../../../quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_callback
    ../../../quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start_timer
    ../../../quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/tc/quick_start
    ../../../quick_start/: qs_tc_basic.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../utils/cmsis/samd21/include/: samd21e15a.h samd21g17a.h samd21g15a.h samd21j17a.h samd21e16a.h samd21.h samd21g16a.h samd21e18a.h samd21g18a.h samd21j15a.h samd21j18a.h samd21e17a.h samd21j16a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../utils/cmsis/samd21/include/pio/: samd21e18a.h samd21j17a.h samd21j15a.h samd21j16a.h samd21j18a.h samd21g15a.h samd21e16a.h samd21g18a.h samd21e15a.h samd21e17a.h samd21g16a.h samd21g17a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../utils/cmsis/samd21/include/instance/: usb.h dsu.h eic.h gclk.h pac0.h tc4.h tc6.h pm.h wdt.h ac.h tcc1.h tc3.h pac2.h sercom4.h sercom2.h pac1.h evsys.h tc5.h tc7.h sercom1.h rtc.h tcc0.h dmac.h sercom5.h sercom3.h sysctrl.h sercom0.h i2s.h tcc2.h adc.h port.h nvmctrl.h mtb.h dac.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../utils/cmsis/samd21/include/component/: tcc.h sysctrl.h gclk.h dsu.h evsys.h usb.h dmac.h wdt.h rtc.h tc.h adc.h mtb.h sercom.h dac.h port.h i2s.h pac.h pm.h nvmctrl.h ac.h eic.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
