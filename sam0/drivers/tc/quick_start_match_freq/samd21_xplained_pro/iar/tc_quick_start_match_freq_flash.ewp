# IAR project tc_quick_start_match_freq_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TC_ASYNC=false; ARM_MATH_CM0PLUS=true; __SAMD21J18A__; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samd21/source; ../../../../system/interrupt; ../../../../system/power; ../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../port; ../../../../../boards; ../..; ../../../../system/reset; ../../../../system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../../boards/samd21_xplained_pro; ../../../../../utils/cmsis/samd21/include; ../../..; ..; ../../../../system/power/power_sam_d_r_h; ../../../tc_sam_d_r_h; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../../../../../utils/header_files; ../../../../system/interrupt/system_interrupt_samd21; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tc_quick_start_match_freq_flash.bin
  ILINK.IlinkOutputFile: tc_quick_start_match_freq_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../utils/cmsis/samd21/include/: samd21g15b.h samd21e17l.h samd21g18au.h samd21e15a.h samd21e17d.h samd21e16l.h samd21g17d.h samd21g17a.h samd21g15a.h samd21e16a.h samd21j16b.h samd21g17au.h samd21g17l.h samd21g16a.h samd21j17d.h samd21e18a.h samd21g18a.h samd21j15a.h samd21j18a.h samd21e16b.h samd21e15l.h samd21e16bu.h samd21j15b.h samd21e17a.h samd21g16b.h samd21j16a.h samd21e15b.h samd21.h samd21g15l.h samd21e15bu.h samd21j17a.h samd21e17du.h samd21g16l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../utils/cmsis/samd21/include/pio/: samd21e18a.h samd21j15b.h samd21e17d.h samd21g17l.h samd21e15b.h samd21g15l.h samd21j17a.h samd21j15a.h samd21g17au.h samd21g16l.h samd21g16b.h samd21j16a.h samd21g17d.h samd21j17d.h samd21e17l.h samd21j18a.h samd21g18au.h samd21g15a.h samd21e16a.h samd21e16bu.h samd21g18a.h samd21e15bu.h samd21e17du.h samd21e15a.h samd21g15b.h samd21e16b.h samd21j16b.h samd21e17a.h samd21g16a.h samd21e15l.h samd21g17a.h samd21e16l.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../utils/cmsis/samd21/include/instance/: usb.h dsu.h eic.h ac1.h gclk.h sbmatrix.h pac0.h tc4.h tc6.h port.h pm.h ac.h tcc1.h tc3.h pac2.h sercom4.h nvmctrl_variant_d.h sercom2.h evsys.h tcc3.h evsys_variant_d.h tc5.h tc7.h wdt.h sercom1.h rtc.h tcc0.h dmac.h sercom5.h sercom3.h sysctrl.h sercom0.h i2s.h tcc2.h port_variant_d.h adc.h pac1.h nvmctrl.h mtb.h dac.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../utils/cmsis/samd21/include/component/: tcc.h sysctrl.h evsys_variant_d.h tcc_lighting.h nvmctrl_variant_d.h gclk.h dsu.h evsys.h dmac.h wdt.h rtc.h sercom.h usb.h tc.h hmatrixb.h tcc_variant_d.h adc.h mtb.h dac.h port.h i2s.h pac.h pm_variant_d.h pm.h nvmctrl.h ac.h eic.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/tc
    ../../../: tc.h
  group sam0/drivers/tc/quick_start_match_freq
    ../../: qs_tc_match_freq.c
  group sam0/drivers/tc/quick_start_match_freq/samd21_xplained_pro
    ../: conf_board.h conf_quick_start.h conf_clocks.h
  group sam0/drivers/tc/quick_start_match_freq/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../tc_sam_d_r_h/: tc.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
