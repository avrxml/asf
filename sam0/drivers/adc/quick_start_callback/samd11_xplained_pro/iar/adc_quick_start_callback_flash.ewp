# IAR project adc_quick_start_callback_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; ARM_MATH_CM0=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../system/interrupt; ../../../../system/clock/clock_samd10_d11; ../..; ../../../../../utils; ../../../../port; ../../../../../boards; ../../../../system/interrupt/system_interrupt_samd10_d11; ../../..; ../../../../../../common/boards; ../../../../system; ../../../../system/pinmux; ../../../../../utils/preprocessor; ..; ../../../../../utils/cmsis/samd11/include; ../../../../../utils/header_files; ../../../../../../common/utils; ../../../../../utils/cmsis/samd11/source; ../../../../../boards/samd11_xplained_pro; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_quick_start_callback_flash.bin
  ILINK.IlinkOutputFile: adc_quick_start_callback_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/adc
    ../../../: adc_callback.c adc.c adc.h adc_callback.h
  group sam0/drivers/adc/quick_start_callback
    ../../: qs_adc_callback.c qs_adc_callback.h
  group sam0/drivers/adc/quick_start_callback/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/adc/quick_start_callback/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/adc/quick_start_dma
    ../../../quick_start_dma/: qs_adc_dma_use.h
  group sam0/drivers/adc/quick_start
    ../../../quick_start/: qs_adc_basic.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../system/clock/clock_samd10_d11/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../utils/cmsis/samd11/include/: samd11d14as.h samd11c14a.h samd11d14am.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../utils/cmsis/samd11/include/component/: rtc.h eic.h gclk.h dsu.h nvmctrl.h ac.h port.h adc.h tcc.h mtb.h tc.h sysctrl.h pm.h evsys.h sercom.h pac.h usb.h dmac.h dac.h wdt.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../utils/cmsis/samd11/include/instance/: sercom2.h dac.h eic.h mtb.h sercom1.h sercom0.h nvmctrl.h sysctrl.h tc1.h dmac.h gclk.h usb.h pac2.h dsu.h evsys.h tcc0.h pac0.h tc2.h rtc.h adc.h pm.h wdt.h port.h ac.h pac1.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../utils/cmsis/samd11/include/pio/: samd11c14a.h samd11d14as.h samd11d14am.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrecursion.h mrepeat.h tpaste.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
