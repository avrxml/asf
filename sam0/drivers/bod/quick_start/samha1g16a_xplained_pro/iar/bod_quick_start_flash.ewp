# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMHA1G16A_XPLAINED_PRO; __SAMHA1G16A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../..; ../../../../port; ../../../../../utils/cmsis/samha1/include; ../../../../../boards; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../../utils/preprocessor; ..; ../../../../../utils/header_files; ../../../../../../common/utils; ../../../../../utils; ../..; ../../../../../boards/samha1g16a_xplained_pro; ../../../bod_sam_d_r_h; ../../../../../utils/cmsis/samha1/source; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use.c
  group sam0/drivers/bod/quick_start/samha1g16a_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/samha1g16a_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../utils/cmsis/samha1/include/: samha1g15ab.h samha1g14a.h samha1e14a.h samha1.h samha1g14ab.h samha1g16ab.h samha1e14ab.h samha1e16ab.h samha1e15ab.h samha1g15a.h samha1e15a.h samha1e16a.h samha1g16a.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../utils/cmsis/samha1/include/instance/: sercom5.h adc.h sercom4.h port.h wdt.h sysctrl.h evsys.h tc7.h pm.h sercom1.h sbmatrix.h nvmctrl.h sercom3.h tcc0.h dmac.h tcc2.h tc3.h tc5.h dsu.h dac.h ac.h pac0.h tc6.h eic.h sercom0.h sercom2.h pac2.h tcc1.h tc4.h linctrl.h pac1.h rtc.h gclk.h mtb.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../utils/cmsis/samha1/include/component/: hmatrixb.h mtb.h evsys.h gclk.h sercom.h tc.h pm.h port.h tcc.h eic.h rtc.h ac.h dac.h adc.h wdt.h pac.h sysctrl.h nvmctrl.h dsu.h dmac.h linctrl.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../utils/cmsis/samha1/include/pio/: samha1e14a.h samha1g16ab.h samha1e16ab.h samha1e15ab.h samha1e14ab.h samha1g15ab.h samha1e16a.h samha1g16a.h samha1g14a.h samha1e15a.h samha1g15a.h samha1g14ab.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
