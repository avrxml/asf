# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../..; ../../../../port; ../../../../../boards; ../../../../../utils/cmsis/samda1/include; ..; ../../../../../utils/cmsis/samda1/source; ../../../../../boards/samda1_xplained_pro; ../../../../system/pinmux; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils; ../..; ../../../bod_sam_d_r_h; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use.c
  group sam0/drivers/bod/quick_start/samda1_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/samda1_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../../utils/cmsis/samda1/include/: samda1j15a.h samda1j16a.h samda1g16a.h samda1.h samda1j15b.h samda1g14a.h samda1e14a.h samda1g16b.h samda1j14b.h samda1g15a.h samda1e14b.h samda1e16a.h samda1j16b.h samda1e15b.h samda1g14b.h samda1g15b.h samda1e15a.h samda1j14a.h samda1e16b.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../utils/cmsis/samda1/include/instance/: tc3.h pac0.h port.h eic.h tc6.h rtc.h pac2.h mtb.h sbmatrix.h pm.h tcc1.h ac.h pac1.h tc5.h tcc2.h sysctrl.h tc4.h dmac.h i2s.h sercom1.h sercom3.h tc7.h usb.h sercom4.h evsys.h dac.h adc.h gclk.h wdt.h nvmctrl.h sercom2.h sercom5.h dsu.h sercom0.h tcc0.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../utils/cmsis/samda1/include/component/: wdt.h pm.h gclk.h nvmctrl.h ac.h hmatrixb.h dsu.h i2s.h port.h tc.h evsys.h eic.h tcc.h sercom.h dmac.h pac.h usb.h rtc.h dac.h adc.h mtb.h sysctrl.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../utils/cmsis/samda1/include/pio/: samda1j15b.h samda1e16b.h samda1e14b.h samda1e15b.h samda1j14a.h samda1e14a.h samda1g15a.h samda1g14a.h samda1g16b.h samda1j14b.h samda1e16a.h samda1g16a.h samda1e15a.h samda1g15b.h samda1g14b.h samda1j16a.h samda1j15a.h samda1j16b.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
