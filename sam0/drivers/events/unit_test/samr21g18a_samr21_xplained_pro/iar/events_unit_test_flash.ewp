# IAR project events_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; TC_ASYNC=false; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; __SAMR21G18A__; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../..; ../../../../system/clock/clock_samd21_r21; ../../../../port; ../../../../../utils/cmsis/samr21/include/instance; ../../../../system/interrupt/system_interrupt_samr21; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/samr21/source; ../../../../../utils; ../../../../sercom; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../rtc; ../../../../../../common/utils; ../../../../system/interrupt; ../../../../tc; ../../../../../utils/cmsis/samr21/include/pio; ..; ../../../../../utils/cmsis/samr21/include/component; ../../../../../boards/samr21_xplained_pro; ../../../../../utils/cmsis/samr21/include; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../../..; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: events_unit_test_flash.bin
  ILINK.IlinkOutputFile: events_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../utils/cmsis/samr21/include/: samr21g17a.h samr21e16a.h samr21e18a.h samr21.h samr21g18a.h samr21g16a.h samr21e17a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../utils/cmsis/samr21/include/instance/: instance_adc.h instance_tc6.h instance_tc3.h instance_tcc0.h instance_pac1.h instance_ac.h instance_pm.h instance_gclk.h instance_pac2.h instance_port.h instance_sercom4.h instance_wdt.h instance_sercom1.h instance_tc5.h instance_dmac.h instance_pac0.h instance_i2s.h instance_tcc2.h instance_nvmctrl.h instance_rfctrl.h instance_evsys.h instance_rtc.h instance_tc4.h instance_sercom5.h instance_eic.h instance_usb.h instance_sysctrl.h instance_dac.h instance_tcc1.h instance_tc7.h instance_sercom3.h instance_sercom0.h instance_sercom2.h instance_mtb.h instance_dsu.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../utils/cmsis/samr21/include/component/: component_port.h component_sercom.h component_adc.h component_mtb.h component_wdt.h component_pac.h component_pm.h component_nvmctrl.h component_dac.h component_ac.h component_rfctrl.h component_dsu.h component_sysctrl.h component_rtc.h component_tc.h component_i2s.h component_evsys.h component_tcc.h component_dmac.h component_eic.h component_usb.h component_gclk.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../utils/cmsis/samr21/include/pio/: pio_samr21e18a.h pio_samr21g18a.h pio_samr21g16a.h pio_samr21e16a.h pio_samr21g17a.h pio_samr21e17a.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_count.c rtc_count.h
  group sam0/drivers/rtc/quick_start_count
    ../../../../rtc/quick_start_count/: qs_rtc_count_basic.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/events
    ../../../: events_hooks.c events.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/unit_test
    ../../: unit_test.c
  group sam0/drivers/events/unit_test/samr21g18a_samr21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/events/unit_test/samr21g18a_samr21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/events/quick_start
    ../../../quick_start/: qs_events_basic.h
  group sam0/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start
    ../../../../tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
