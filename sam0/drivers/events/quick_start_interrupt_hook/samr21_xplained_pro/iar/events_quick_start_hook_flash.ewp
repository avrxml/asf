# IAR project events_quick_start_hook_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EVENTS_INTERRUPT_HOOKS_MODE=true; ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__; TC_ASYNC=false
  ICCARM.CCIncludePath2: ../../../../system/interrupt; ../../../../../boards/samr21_xplained_pro; ../../../../../utils/cmsis/samr21/include; ../..; ../../../../port; ../../../../../boards; ../../..; ../../../../system/interrupt/system_interrupt_samr21; ..; ../../../../../../common/boards; ../../../../system/clock/clock_samd21_r21; ../../../../system/pinmux; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/samr21/source; ../../../../../utils/header_files; ../../../../../../common/utils; ../../../../../utils; ../../../../tc; ../../../../system; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: events_quick_start_hook_flash.bin
  ILINK.IlinkOutputFile: events_quick_start_hook_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/samr21_xplained_pro
    ../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../utils/cmsis/samr21/include/: samr21g17a.h samr21e16a.h samr21e18a.h samr21.h samr21g18a.h samr21g16a.h samr21e17a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../utils/cmsis/samr21/include/instance/: dac.h port.h nvmctrl.h tc3.h sysctrl.h sercom1.h sercom0.h tcc1.h wdt.h gclk.h evsys.h tc6.h pac2.h pac0.h sercom4.h rtc.h sercom2.h mtb.h rfctrl.h eic.h tc7.h tcc2.h ac.h tcc0.h tc4.h sercom3.h sercom5.h usb.h tc5.h dmac.h adc.h pac1.h i2s.h pm.h dsu.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../utils/cmsis/samr21/include/pio/: samr21e16a.h samr21e17a.h samr21g17a.h samr21g16a.h samr21e18a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../utils/cmsis/samr21/include/component/: eic.h evsys.h mtb.h adc.h rfctrl.h gclk.h sysctrl.h tcc.h i2s.h ac.h pm.h dmac.h rtc.h dsu.h port.h pac.h wdt.h nvmctrl.h usb.h tc.h dac.h sercom.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/tc
    ../../../../tc/: tc.c tc.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start
    ../../../../tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/events
    ../../../: events_hooks.c events.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../: qs_events_interrupt_hook.c qs_events_interrupt_hook.h
  group sam0/drivers/events/quick_start_interrupt_hook/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/events/quick_start_interrupt_hook/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/events/quick_start
    ../../../quick_start/: qs_events_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
