# IAR project adc_configurations_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; SYSTICK_MODE; BOARD=SAMD21_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../utils/cmsis/samd21/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/power; ../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../drivers/adc; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ..; ../../../../drivers/system/reset; ../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../../boards/samd21_xplained_pro; ../../../../utils/cmsis/samd21/include; ../../../../drivers/adc/adc_sam_d_r_h; ../../../../../common2/services/delay/sam0; ../..; ../../../../drivers/system/power/power_sam_d_r_h; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ../../../../drivers/system/interrupt/system_interrupt_samd21; ../../../../utils/stdio/stdio_serial; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_configurations_example_flash.bin
  ILINK.IlinkOutputFile: adc_configurations_example_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/applications/adc_configurations_example
    ../../: adc_configure.c adc_temp.c main.c adc_temp.h adc_configure.h
  group sam0/applications/adc_configurations_example/samd21_xplained_pro
    ../: conf_board.h conf_example.h conf_clocks.h
  group sam0/applications/adc_configurations_example/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../utils/cmsis/samd21/include/: samd21e16l.h samd21j16b.h samd21j18a.h samd21g16b.h samd21g18au.h samd21e16b.h samd21g18a.h samd21e15l.h samd21j15a.h samd21e17d.h samd21g17au.h samd21g17d.h samd21g17l.h samd21j17d.h samd21.h samd21g16a.h samd21g17a.h samd21e15bu.h samd21g15l.h samd21e17a.h samd21e15a.h samd21g16l.h samd21e17du.h samd21j15b.h samd21e17l.h samd21e16bu.h samd21e18a.h samd21g15a.h samd21e15b.h samd21e16a.h samd21g15b.h samd21j17a.h samd21j16a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../utils/cmsis/samd21/include/pio/: samd21g15a.h samd21g15b.h samd21g15l.h samd21j15b.h samd21e15bu.h samd21j15a.h samd21g16l.h samd21g16a.h samd21g18a.h samd21j16a.h samd21j18a.h samd21g17au.h samd21e16bu.h samd21e16l.h samd21e15l.h samd21e18a.h samd21g16b.h samd21e16a.h samd21e15b.h samd21g17l.h samd21e17l.h samd21j17a.h samd21e17du.h samd21g17d.h samd21g17a.h samd21j16b.h samd21j17d.h samd21e17a.h samd21e16b.h samd21g18au.h samd21e15a.h samd21e17d.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../utils/cmsis/samd21/include/instance/: tcc3.h tcc2.h tcc0.h dac.h dsu.h nvmctrl_variant_d.h evsys_variant_d.h tcc1.h usb.h tc5.h eic.h wdt.h sercom3.h rtc.h dmac.h gclk.h tc4.h sercom5.h pac2.h port.h sercom4.h sercom1.h tc6.h pac1.h pac0.h evsys.h sercom2.h pm.h ac1.h ac.h sercom0.h nvmctrl.h port_variant_d.h sysctrl.h adc.h tc3.h sbmatrix.h i2s.h mtb.h tc7.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../utils/cmsis/samd21/include/component/: mtb.h i2s.h usb.h tc.h dsu.h pm_variant_d.h nvmctrl_variant_d.h tcc_variant_d.h evsys.h tcc.h adc.h rtc.h port.h sysctrl.h hmatrixb.h pm.h gclk.h sercom.h nvmctrl.h tcc_lighting.h eic.h wdt.h dac.h pac.h evsys_variant_d.h ac.h dmac.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/adc
    ../../../../drivers/adc/: adc_callback.h adc.h
  group sam0/drivers/adc/adc_sam_d_r_h
    ../../../../drivers/adc/adc_sam_d_r_h/: adc_callback.c adc.c adc_feature.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samd21_xplained_pro
    ../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
