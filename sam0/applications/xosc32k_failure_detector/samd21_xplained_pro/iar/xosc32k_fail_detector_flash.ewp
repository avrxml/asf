# IAR project xosc32k_fail_detector_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EVENTS_INTERRUPT_HOOKS_MODE=true; ARM_MATH_CM0=true; __SAMD21J18A__; TC_ASYNC=true; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../utils/cmsis/samd21/source; ../../../../utils/cmsis/samd21/include; ../../../../drivers/system/clock/clock_samd21_r21; ../../../../drivers/tc; ../../../../drivers/port; ../../../../boards; ../../../../drivers/events; ../../../../drivers/system/interrupt/system_interrupt_samd21; ../../../../../common/boards; ../../../../drivers/system; ../../../../drivers/system/pinmux; ../..; ../../../../utils/preprocessor; ..; ../../../../utils/header_files; ../../../../../common/utils; ../../../../drivers/system/clock; ../../../../utils; ../../../../drivers/system/interrupt; ../../../../boards/samd21_xplained_pro; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: xosc32k_fail_detector_flash.bin
  ILINK.IlinkOutputFile: xosc32k_fail_detector_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc.c tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/quick_start
    ../../../../drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../drivers/system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/events
    ../../../../drivers/events/: events.c events_hooks.c events.h events_common.h events_hooks.h
  group sam0/drivers/events/quick_start
    ../../../../drivers/events/quick_start/: qs_events_basic.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../../drivers/events/quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../utils/cmsis/samd21/include/: samd21j18a.h samd21g18a.h samd21j15a.h samd21g17a.h samd21.h samd21g16a.h samd21e15a.h samd21e18a.h samd21g15a.h samd21e16a.h samd21e17a.h samd21j17a.h samd21j16a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../utils/cmsis/samd21/include/pio/: samd21g15a.h samd21j16a.h samd21j15a.h samd21g16a.h samd21g18a.h samd21j18a.h samd21e18a.h samd21e16a.h samd21j17a.h samd21g17a.h samd21e17a.h samd21e15a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../utils/cmsis/samd21/include/instance/: tcc2.h tcc0.h dac.h dsu.h tcc1.h usb.h eic.h pm.h wdt.h rtc.h dmac.h tc4.h sercom5.h pac2.h port.h sercom1.h tc6.h pac1.h pac0.h gclk.h evsys.h sercom2.h sercom4.h ac.h tc5.h sercom3.h sercom0.h nvmctrl.h sysctrl.h adc.h tc3.h i2s.h mtb.h tc7.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../utils/cmsis/samd21/include/component/: mtb.h i2s.h usb.h tc.h dsu.h evsys.h tcc.h adc.h rtc.h port.h sysctrl.h pm.h eic.h gclk.h sercom.h nvmctrl.h wdt.h dac.h pac.h ac.h dmac.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/applications/xosc32k_failure_detector
    ../../: xosc32k_failure_detector.c
  group sam0/applications/xosc32k_failure_detector/samd21_xplained_pro
    ../: conf_board.h conf_example.h conf_clocks.h
  group sam0/applications/xosc32k_failure_detector/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samd21_xplained_pro
    ../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
