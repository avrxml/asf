# IAR project led_toggle_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; EXTINT_CALLBACK_MODE=true; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/system/clock/clock_samd20; ../../../../drivers/port; ../../../../utils/preprocessor; ../../../../boards/samd20_xplained_pro; ../../../../utils/cmsis/samd20/source; ../../../../utils; ../../../../boards; ..; ../..; ../../../../../common/utils; ../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../drivers/system/interrupt; ../../../../utils/cmsis/samd20/include/component; ../../../../utils/cmsis/samd20/include/pio; ../../../../../common/boards; ../../../../utils/cmsis/samd20/include; ../../../../drivers/system/pinmux; ../../../../utils/cmsis/samd20/include/instance; ../../../../drivers/system; ../../../../drivers/extint; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: led_toggle_flash.bin
  ILINK.IlinkOutputFile: led_toggle_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/samd20_xplained_pro
    ../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd20/source
    ../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../utils/cmsis/samd20/include/: samd20j14.h samd20j16.h samd20e14.h samd20g17.h samd20g18.h samd20.h samd20e16.h samd20e15.h samd20j18.h samd20g14.h samd20e17.h samd20j15.h samd20j17.h samd20g16.h samd20g15.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../utils/cmsis/samd20/include/pio/: pio_samd20j15.h pio_samd20g14.h pio_samd20e1f.h pio_samd20g16.h pio_samd20e16.h pio_samd20g15.h pio_samd20g17.h pio_samd20e14.h pio_samd20j17.h pio_samd20j18.h pio_samd20j14.h pio_samd20e17.h pio_samd20g18.h pio_samd20e15.h pio_samd20j16.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../utils/cmsis/samd20/include/instance/: instance_tc7.h instance_port.h instance_tc1.h instance_eic.h instance_gclk.h instance_pac2.h instance_pac1.h instance_wdt.h instance_ac.h instance_dsu.h instance_tc2.h instance_sercom2.h instance_rtc.h instance_dac.h instance_tc4.h instance_adc.h instance_sercom0.h instance_sercom4.h instance_sysctrl.h instance_tc0.h instance_nvmctrl.h instance_sercom3.h instance_tc5.h instance_tc6.h instance_tc3.h instance_sercom1.h instance_evsys.h instance_pac0.h instance_sercom5.h instance_pm.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../utils/cmsis/samd20/include/component/: component_sysctrl.h component_nvmctrl.h component_gclk.h component_port.h component_evsys.h component_rtc.h component_dsu.h component_eic.h component_dac.h component_tc.h component_adc.h component_ac.h component_sercom.h component_wdt.h component_pac.h component_pm.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint.c extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/quick_start_callback
    ../../../../drivers/extint/quick_start_callback/: qs_extint_callback.h
  group sam0/drivers/extint/quick_start_polled
    ../../../../drivers/extint/quick_start_polled/: qs_extint_basic.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/applications/led_toggle
    ../../: led_toggle.c
  group sam0/applications/led_toggle/samd20_xplained_pro
    ../: conf_board.h conf_clocks.h conf_extint.h
  group sam0/applications/led_toggle/samd20_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
