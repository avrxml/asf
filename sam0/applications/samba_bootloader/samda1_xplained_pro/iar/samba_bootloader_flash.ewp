# IAR project samba_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../utils/cmsis/samda1/include; ../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../boards/samda1_xplained_pro; ../../../../drivers/system/interrupt/system_interrupt_samda; ../../../../drivers/system/power/power_sam_d_r_h; ..; ../..; ../../../../utils/cmsis/samda1/source; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: samba_bootloader_flash.bin
  ILINK.IlinkOutputFile: samba_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samda1/source
    ../../../../utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/cmsis/samda1/include
    ../../../../utils/cmsis/samda1/include/: samda1j16a.h samda1e15b.h samda1g16a.h samda1g15b.h samda1g14b.h samda1.h samda1e14b.h samda1j16b.h samda1j15b.h samda1j14b.h samda1e16b.h samda1g14a.h samda1e14a.h samda1j14a.h samda1e16a.h samda1e15a.h samda1g15a.h samda1j15a.h samda1g16b.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../utils/cmsis/samda1/include/instance/: sercom1.h nvmctrl.h i2s.h sercom5.h sercom0.h sercom2.h port.h tc6.h tc4.h rtc.h sercom3.h sbmatrix.h pac1.h gclk.h ac.h sysctrl.h dmac.h tc5.h mtb.h pm.h usb.h dsu.h tcc1.h wdt.h tc7.h adc.h tc3.h dac.h sercom4.h pac0.h tcc0.h evsys.h tcc2.h pac2.h eic.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../utils/cmsis/samda1/include/pio/: samda1g15b.h samda1j14b.h samda1e15b.h samda1e16a.h samda1g14a.h samda1j14a.h samda1e14b.h samda1g16b.h samda1j15a.h samda1e16b.h samda1j16b.h samda1g15a.h samda1e15a.h samda1j16a.h samda1e14a.h samda1j15b.h samda1g16a.h samda1g14b.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../utils/cmsis/samda1/include/component/: mtb.h i2s.h evsys.h rtc.h hmatrixb.h usb.h eic.h pac.h sysctrl.h wdt.h pm.h nvmctrl.h sercom.h dac.h port.h tcc.h dmac.h gclk.h tc.h ac.h dsu.h adc.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/applications/samba_bootloader
    ../../: main.c sam_ba_monitor.c usart_sam_ba.c sam_ba_monitor.h usart_sam_ba.h
  group sam0/applications/samba_bootloader/samda1_xplained_pro
    ../: conf_board.h conf_bootloader.h conf_clocks.h
  group sam0/applications/samba_bootloader/samda1_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samda1_xplained_pro
    ../../../../boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
