# IAR project waveform_generator_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TC_ASYNC=false; BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; DAC_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../drivers/dac; ../../../../drivers/system/clock/clock_samd20; ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../boards/samd20_xplained_pro; ../../../../utils/cmsis/samd20/source; ../../../../utils; ../..; ../../../../boards; ../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../../drivers/events/events_sam_d_r_h; ../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../drivers/system/interrupt; ../../../../drivers/dac/dac_sam_d_c_h; ../../../../drivers/tc; ..; ../../../../drivers/system/power; ../../../../drivers/system/power/power_sam_d_r_h; ../../../../drivers/tc/tc_sam_d_r_h; ../../../../../common/boards; ../../../../utils/cmsis/samd20/include; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/events; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: waveform_generator_flash.bin
  ILINK.IlinkOutputFile: waveform_generator_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/dac
    ../../../../drivers/dac/: dac_callback.h dac.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../../drivers/dac/dac_sam_d_c_h/: dac_callback.c dac.c dac_feature.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../drivers/system/clock/clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../drivers/events/events_sam_d_r_h/: events.c
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../utils/cmsis/samd20/include/: samd20j14b.h samd20j14.h samd20j16b.h samd20j16.h samd20e15b.h samd20e14.h samd20j15b.h samd20g18.h samd20g17.h samd20e18.h samd20g14b.h samd20e16.h samd20e15.h samd20j18.h samd20g16.h samd20e14b.h samd20g16b.h samd20g14.h samd20e17.h samd20j15.h samd20j17.h samd20g17u.h samd20.h samd20g18u.h samd20g15b.h samd20e16b.h samd20g15.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../utils/cmsis/samd20/include/instance/: evsys.h pac2.h tc1.h pac0.h tc2.h eic.h sercom1.h dac.h pm.h sercom2.h ac.h nvmctrl.h sercom4.h sercom3.h tc6.h port.h dsu.h tc4.h wdt.h sercom5.h sercom0.h adc.h tc3.h tc0.h sysctrl.h rtc.h tc7.h gclk.h tc5.h pac1.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../utils/cmsis/samd20/include/component/: wdt.h adc.h rtc.h dac.h dsu.h gclk.h evsys.h pac.h eic.h port.h sercom.h sysctrl.h pm.h tc.h nvmctrl.h ac.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../utils/cmsis/samd20/include/pio/: samd20g16.h samd20j15b.h samd20e18.h samd20g18.h samd20e14.h samd20g18u.h samd20e15b.h samd20e15.h samd20j14.h samd20e14b.h samd20g15b.h samd20j17.h samd20j18.h samd20e17.h samd20j14b.h samd20e16b.h samd20g15.h samd20g14b.h samd20e16.h samd20j16b.h samd20j15.h samd20g17u.h samd20g16b.h samd20j16.h samd20g14.h samd20g17.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrecursion.h mrepeat.h preprocessor.h stringz.h
  group sam0/applications/waveform_generator
    ../../: main.c
  group sam0/applications/waveform_generator/samd20_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/applications/waveform_generator/samd20_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samd20_xplained_pro
    ../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
