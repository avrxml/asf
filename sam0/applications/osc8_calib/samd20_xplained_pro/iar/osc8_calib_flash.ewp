# IAR project osc8_calib_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD20_XPLAINED_PRO; SYSTICK_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; USART_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../drivers/system/clock/clock_samd20; ../../../../drivers/port; ../../../../utils/preprocessor; ../../../../boards/samd20_xplained_pro; ../../../../utils/cmsis/samd20/source; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/sercom; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../..; ../../../../../common/utils; ../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../drivers/system/interrupt; ../../../../drivers/tc; ../../../../../common2/services/delay/sam0; ../../../../../common/boards; ../../../../utils/cmsis/samd20/include; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/events; ../../../../utils/header_files; ../../../../drivers/system/clock; ../../../../utils/stdio/stdio_serial; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: osc8_calib_flash.bin
  ILINK.IlinkOutputFile: osc8_calib_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../utils/cmsis/samd20/include/: samd20j14.h samd20j16.h samd20e14.h samd20g17.h samd20g18.h samd20.h samd20e18.h samd20g14.h samd20e16.h samd20e15.h samd20j18.h samd20g16.h samd20e17.h samd20j15.h samd20j17.h samd20g15.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../utils/cmsis/samd20/include/instance/: evsys.h tc1.h pac0.h eic.h sercom2.h pac2.h sercom1.h dac.h rtc.h ac.h nvmctrl.h sercom4.h sercom3.h tc6.h port.h dsu.h tc4.h wdt.h sercom5.h adc.h tc3.h tc0.h pm.h sysctrl.h tc7.h gclk.h tc5.h tc2.h pac1.h sercom0.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../utils/cmsis/samd20/include/component/: wdt.h sercom.h adc.h rtc.h dac.h dsu.h gclk.h evsys.h pac.h eic.h port.h sysctrl.h pm.h tc.h nvmctrl.h ac.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../utils/cmsis/samd20/include/pio/: samd20g16.h samd20g18.h samd20e18.h samd20e1f.h samd20e14.h samd20e15.h samd20j14.h samd20j17.h samd20j18.h samd20e17.h samd20g15.h samd20e16.h samd20j15.h samd20j16.h samd20g17.h samd20g14.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrecursion.h mrepeat.h preprocessor.h stringz.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/quick_start
    ../../../../drivers/events/quick_start/: qs_events_basic.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../../drivers/events/quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc.c tc_interrupt.h tc.h
  group sam0/drivers/tc/quick_start_callback
    ../../../../drivers/tc/quick_start_callback/: qs_tc_callback.h
  group sam0/drivers/tc/quick_start
    ../../../../drivers/tc/quick_start/: qs_tc_basic.h
  group sam0/drivers/tc/quick_start_dma
    ../../../../drivers/tc/quick_start_dma/: qs_tc_dma.h
  group sam0/drivers/tc/quick_start_timer
    ../../../../drivers/tc/quick_start_timer/: qs_tc_timer.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/applications/osc8_calib
    ../../: osc8_calib.c
  group sam0/applications/osc8_calib/samd20_xplained_pro
    ../: conf_board.h conf_example.h conf_clocks.h
  group sam0/applications/osc8_calib/samd20_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
