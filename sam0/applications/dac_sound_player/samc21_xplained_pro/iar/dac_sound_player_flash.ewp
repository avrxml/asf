# IAR project dac_sound_player_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; DAC_CALLBACK_MODE=true; BOARD=SAMC21_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; __SAMC21J18A__
  ICCARM.CCIncludePath2: ../../../../drivers/dac; ../../../../utils/cmsis/samc21/include; ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../utils/cmsis/samc21/source; ..; ../../../../utils/preprocessor; ../../../../utils; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/system/interrupt/system_interrupt_samc20_c21; ../../../../drivers/events/events_sam_l_c; ../../../../drivers/tc/tc_sam_l_c; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/dac/dac_sam_d_c_h; ../..; ../../../../drivers/tc; ../../../../drivers/system/power/power_sam_c; ../../../../drivers/system/clock/clock_samc20_c21; ../../../../drivers/system/reset/reset_sam_c; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/events; ../../../../utils/header_files; ../../../../boards/samc21_xplained_pro; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_sound_player_flash.bin
  ILINK.IlinkOutputFile: dac_sound_player_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/dac
    ../../../../drivers/dac/: dac.h dac_callback.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../../drivers/dac/dac_sam_d_c_h/: dac_callback.c dac.c dac_feature.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../drivers/system/clock/clock_samc20_c21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../drivers/system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../drivers/system/power/power_sam_c/: power.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../drivers/system/reset/reset_sam_c/: reset.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events.h events_hooks.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../drivers/events/events_sam_l_c/: events.c
  group sam0/boards/samc21_xplained_pro
    ../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samc21/source
    ../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../utils/cmsis/samc21/include/: samc21g16a.h samc21j16a.h samc21e15a.h samc21.h samc21g18a.h samc21e16a.h samc21e18a.h samc21j15a.h samc21e17a.h samc21j17a.h samc21g15a.h samc21j18a.h samc21g17a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../utils/cmsis/samc21/include/instance/: tc4.h freqm.h ccl.h can0.h port.h dsu.h adc0.h supc.h osc32kctrl.h oscctrl.h sdadc.h nvmctrl.h divas.h rstc.h pac.h eic.h pm.h ac.h evsys.h sercom4.h tcc1.h mtb.h tc1.h sercom0.h gclk.h tc0.h mclk.h sercom2.h tal.h hmatrixhs.h tcc2.h sercom5.h tc2.h sercom1.h tsens.h dmac.h tcc0.h tc3.h sercom3.h can1.h adc1.h wdt.h rtc.h dac.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../utils/cmsis/samc21/include/pio/: samc21e15a.h samc21e16a.h samc21e18a.h samc21j18a.h samc21j17a.h samc21g18a.h samc21j15a.h samc21g16a.h samc21j16a.h samc21e17a.h samc21g17a.h samc21g15a.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../utils/cmsis/samc21/include/component/: rtc.h osc32kctrl.h can.h adc.h mtb.h freqm.h dsu.h tsens.h port.h ccl.h pm.h rstc.h dmac.h dac.h evsys.h sercom.h gclk.h oscctrl.h mclk.h tcc.h tal.h sdadc.h eic.h tc.h supc.h pac.h hmatrixb.h divas.h wdt.h nvmctrl.h ac.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/applications/dac_sound_player
    ../../: dac_sound_player.c data.x
  group sam0/applications/dac_sound_player/samc21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/applications/dac_sound_player/samc21_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
