# IAR project sleepwalking_adc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; SYSTICK_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; __SAMR21G18A__
  ICCARM.CCIncludePath2: ../../../../drivers/system/clock/clock_samd21_r21; ../../../../drivers/port; ../../../../utils/cmsis/samr21/include/instance; ../../../../drivers/system/interrupt/system_interrupt_samr21; ../../../../utils/preprocessor; ../../../../utils/cmsis/samr21/source; ../../../../../common2/services/delay; ../../../../utils; ../../../../boards; ../../../../drivers/adc; ../../../../drivers/rtc; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../utils/cmsis/samr21/include/pio; ..; ../../../../utils/cmsis/samr21/include/component; ../../../../../common2/services/delay/sam0; ../../../../boards/samr21_xplained_pro; ../../../../utils/cmsis/samr21/include; ../../../../../common/boards; ../..; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/events; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepwalking_adc_flash.bin
  ILINK.IlinkOutputFile: sleepwalking_adc_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../drivers/system/clock/clock_samd21_r21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events.c events.h events_hooks.h events_common.h
  group sam0/drivers/events/quick_start
    ../../../../drivers/events/quick_start/: qs_events_basic.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../../../drivers/events/quick_start_interrupt_hook/: qs_events_interrupt_hook.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/adc
    ../../../../drivers/adc/: adc_callback.c adc.c adc_callback.h adc.h
  group sam0/drivers/adc/quick_start_dma
    ../../../../drivers/adc/quick_start_dma/: qs_adc_dma_use.h
  group sam0/drivers/adc/quick_start_callback
    ../../../../drivers/adc/quick_start_callback/: qs_adc_callback.h
  group sam0/drivers/adc/quick_start
    ../../../../drivers/adc/quick_start/: qs_adc_basic.h
  group sam0/drivers/rtc
    ../../../../drivers/rtc/: rtc_count.c rtc_count.h
  group sam0/drivers/rtc/quick_start_count
    ../../../../drivers/rtc/quick_start_count/: qs_rtc_count_basic.h
  group sam0/boards/samr21_xplained_pro
    ../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/applications/sleepwalking_adc
    ../../: vcc_monitor.c
  group sam0/applications/sleepwalking_adc/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/applications/sleepwalking_adc/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../utils/cmsis/samr21/include/: samr21g17a.h samr21g18a.h samr21e17a.h samr21e16a.h samr21.h samr21e18a.h samr21g16a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../utils/cmsis/samr21/include/component/: component_wdt.h component_pm.h component_tcc.h component_gclk.h component_dac.h component_nvmctrl.h component_dsu.h component_ac.h component_rfctrl.h component_i2s.h component_port.h component_tc.h component_evsys.h component_eic.h component_dmac.h component_sercom.h component_pac.h component_usb.h component_rtc.h component_sysctrl.h component_adc.h component_mtb.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../utils/cmsis/samr21/include/instance/: instance_pm.h instance_sercom5.h instance_dmac.h instance_tcc0.h instance_tcc2.h instance_mtb.h instance_i2s.h instance_pac0.h instance_ac.h instance_sercom4.h instance_adc.h instance_pac2.h instance_sercom3.h instance_tcc1.h instance_wdt.h instance_rtc.h instance_sysctrl.h instance_evsys.h instance_tc7.h instance_nvmctrl.h instance_sercom1.h instance_pac1.h instance_tc3.h instance_usb.h instance_tc5.h instance_gclk.h instance_dsu.h instance_dac.h instance_tc6.h instance_rfctrl.h instance_eic.h instance_sercom2.h instance_port.h instance_sercom0.h instance_tc4.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../utils/cmsis/samr21/include/pio/: pio_samr21g17a.h pio_samr21e16a.h pio_samr21e18a.h pio_samr21e17a.h pio_samr21g18a.h pio_samr21g16a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
