# IAR project wav_audio_player_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CYCLE_MODE; BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; RTC_CALENDAR_ASYNC=false; SD_MMC_ENABLE; DAC_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../drivers/dac; ../../../../drivers/system/clock/clock_samd20; ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../..; ../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../utils/cmsis/samd20/source; ../../../../../common2/services/delay; ../../../../drivers/sercom/spi; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../../drivers/events/events_sam_d_r_h; ../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../drivers/system/interrupt; ../../../../drivers/dac/dac_sam_d_c_h; ../../../../drivers/events; ../../../../drivers/tc; ../../../../drivers/rtc; ..; ../../../../../common2/services/delay/sam0; ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../drivers/system/power/power_sam_d_r_h; ../../../../drivers/tc/tc_sam_d_r_h; ../../../../../common/boards; ../../../../utils/cmsis/samd20/include; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/rtc/rtc_sam_d_r_h; ../../../../../common2/components/memory/sd_mmc; ../../../../utils/header_files; ../../../../boards/samd20_xplained_pro; ../../../../utils/stdio/stdio_serial; ../../../../../common/services/storage/ctrl_access; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wav_audio_player_flash.bin
  ILINK.IlinkOutputFile: wav_audio_player_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/dac
    ../../../../drivers/dac/: dac_callback.h dac.h
  group sam0/drivers/dac/dac_sam_d_c_h
    ../../../../drivers/dac/dac_sam_d_c_h/: dac_callback.c dac.c dac_feature.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../drivers/system/clock/clock_samd20/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../drivers/events/events_sam_d_r_h/: events.c
  group sam0/drivers/rtc
    ../../../../drivers/rtc/: rtc_calendar.h rtc_tamper.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../drivers/rtc/rtc_sam_d_r_h/: rtc_calendar.c
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../utils/cmsis/samd20/include/: samd20j14b.h samd20j14.h samd20j16b.h samd20j16.h samd20e15b.h samd20j15b.h samd20g18.h samd20.h samd20e18.h samd20g14b.h samd20e16.h samd20e15.h samd20j18.h samd20e14.h samd20g16.h samd20e14b.h samd20g16b.h samd20g14.h samd20e17.h samd20j15.h samd20j17.h samd20g17u.h samd20g17.h samd20g18u.h samd20g15b.h samd20e16b.h samd20g15.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../utils/cmsis/samd20/include/pio/: samd20e16.h samd20g16.h samd20j15b.h samd20e18.h samd20g18.h samd20e14.h samd20e15b.h samd20e15.h samd20j14.h samd20e14b.h samd20g15b.h samd20j17.h samd20j18.h samd20g18u.h samd20e17.h samd20j14b.h samd20e16b.h samd20g15.h samd20g14b.h samd20j16b.h samd20j15.h samd20g17u.h samd20g16b.h samd20j16.h samd20g14.h samd20g17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../utils/cmsis/samd20/include/instance/: evsys.h pac2.h tc1.h pac0.h tc2.h eic.h sercom1.h dac.h pm.h sercom2.h ac.h sercom4.h sercom3.h tc6.h port.h dsu.h tc4.h wdt.h sercom5.h sercom0.h adc.h tc3.h tc0.h sysctrl.h rtc.h tc7.h gclk.h tc5.h pac1.h nvmctrl.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../utils/cmsis/samd20/include/component/: wdt.h adc.h rtc.h dac.h dsu.h gclk.h evsys.h pac.h eic.h sercom.h sysctrl.h pm.h tc.h nvmctrl.h port.h ac.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/boards/samd20_xplained_pro
    ../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/applications/wav_audio_player
    ../../: main.c
  group sam0/applications/wav_audio_player/samd20_xplained_pro
    ../: conf_board.h conf_sd_mmc.h conf_access.h conf_fatfs.h conf_spi.h conf_clocks.h
  group sam0/applications/wav_audio_player/samd20_xplained_pro/iar
    ./: asf.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c diskio.h integer.h ffconf.h ff.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
  group common2/components/memory/sd_mmc
    ../../../../../common2/components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_spi.c sd_mmc_protocol.h sd_mmc_spi.h sd_mmc_mem.h sd_mmc.h
